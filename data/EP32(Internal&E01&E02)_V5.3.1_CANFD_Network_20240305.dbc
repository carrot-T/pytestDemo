VERSION ""

NS_ :

BS_:

BU_: GW_FD5 GW_FD6 GW_FD3 GW_FD4 GW_FD1 GW_FD2 PDCS_FD1 PDCU SRR3 SRR4 ADCU_FD3 BDCS DDCU CDCS ADCS_FD3 CDCS_OverSea TBOX FLC_ME_FD3 FLC_FD3 ICU_E02 ICU PDCS_HVM_FD1 TBOX_OverSea BMS ISC GCU EMS IDB ESC_FD3 EHB_FD3 MCU IMU ACU EPS WPC CDU AMP BAM PDCS_FD3 EVCC REPB ADCS_FD6 ADCU_FD6 FLC_ME_FD6 FLC_FD6 DLC GW_FD7 ESC_FD6 EHB_FD6

BO_ 310 ADCS_F12_136: 16 FLC_ME_FD3
 SG_ ADCS12_FCWWarnAudioplay : 5|1@0+ (1,0) [0|1] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_RCTAWarnAudioplay : 9|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_FCTAWarnAudioplay : 13|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_SpeedWarnAudioplay : 16|1@0+ (1,0) [0|1] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_DOWWarnAudioplay : 21|1@0+ (1,0) [0|1] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_DCLCAudioplay : 31|3@0+ (1,0) [0|7] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_PilotAudioPlay : 33|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_HandOffAudioplay : 35|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_NNPCancelAudioPlay : 38|1@0+ (1,0) [0|1] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_RCWWarnAudioplay : 39|1@0+ (1,0) [0|1] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_MRMAudioPlay : 41|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_NNP_ResumeAudioplay : 43|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_Lcsndrequest : 45|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_Lcsndrconfirm : 47|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_DriveOffBroadcast : 50|1@0+ (1,0) [0|1] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_EyeOffBroadcast : 53|1@0+ (1,0) [0|1] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_longitudDisableInfo : 59|4@0+ (1,0) [0|15] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_SpeedAdaptComfirm : 69|1@0+ (1,0) [0|1] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_PayModeConfirm : 72|1@0+ (1,0) [0|1] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_longitudCtrlSysInfo : 76|4@0+ (1,0) [0|15] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS12_ADAS_DriveOffinhibition : 80|1@0+ (1,0) [0|1] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS12_P2N_State_Reminder : 83|3@0+ (1,0) [0|7] "NoUnit" ACU,ICU_E02,GW_FD4,GW_FD1,ICU,CDCS,CDCS_OverSea
 SG_ ADCS12_NNP_State_Reminder : 86|3@0+ (1,0) [0|7] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS12_NNP_LightRemind : 87|1@0+ (1,0) [0|1] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS12_LaneChangePendingAlert : 90|1@0+ (1,0) [0|1] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_NPilotSysInfo : 95|5@0+ (1,0) [0|31] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_LCAudioPlay : 99|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_NNP_Scenarios_AudioPlay : 103|4@0+ (1,0) [0|15] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS12_NNP_RINO : 111|4@0+ (1,0) [0|15] "NoUnit" GW_FD4,CDCS,CDCS_OverSea

BO_ 400 ADCS_Fr05_190: 64 ADCU_FD3
 SG_ ADCS5_RPA_slot_ID_1_P0_X : 7|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_1_P0_Y : 9|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_1_P1_X : 27|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_1_P1_Y : 45|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_1_P2_X : 63|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_1_P2_Y : 65|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_1_P3_X : 83|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_1_P3_Y : 101|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_Angle1 : 118|15@0+ (0.001,0) [0|32.767] "rad/s" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_ParkingSlotDepth1 : 135|11@0+ (0.01,0) [0|20.47] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_ParkingSlotWidth1 : 138|11@0+ (0.01,0) [0|20.47] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_1_Status : 155|3@0+ (1,0) [0|7] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_ParkingSlotType1 : 157|2@0+ (1,0) [0|3] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_ParkingSlotDirection1 : 159|2@0+ (1,0) [0|3] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_2_P0_X : 183|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_2_P0_Y : 185|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_2_P1_X : 203|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_2_P1_Y : 221|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_2_P2_X : 239|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_2_P2_Y : 241|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_2_P3_X : 259|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_2_P3_Y : 277|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_Angle2 : 294|15@0+ (0.001,0) [0|32.767] "rad/s" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_ParkingSlotDepth2 : 311|11@0+ (0.01,0) [0|20.47] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_ParkingSlotWidth2 : 314|11@0+ (0.01,0) [0|20.47] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_2_Status : 331|3@0+ (1,0) [0|7] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_ParkingSlotType2 : 333|2@0+ (1,0) [0|3] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_ParkingSlotDirection2 : 335|2@0+ (1,0) [0|3] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_3_P0_X : 359|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_3_P0_Y : 361|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_3_P1_X : 379|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_3_P1_Y : 397|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_3_P2_X : 415|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_3_P2_Y : 417|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_3_P3_X : 435|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_3_P3_Y : 453|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_Angle3 : 470|15@0+ (0.001,0) [0|32.767] "rad/s" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_ParkingSlotDepth3 : 487|11@0+ (0.01,0) [0|20.47] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_ParkingSlotWidth3 : 490|11@0+ (0.01,0) [0|20.47] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_slot_ID_3_Status : 507|3@0+ (1,0) [0|7] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_ParkingSlotType3 : 509|2@0+ (1,0) [0|3] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS5_RPA_ParkingSlotDirection3 : 511|2@0+ (1,0) [0|3] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea

BO_ 401 ADCS_Fr06_191: 64 ADCU_FD3
 SG_ ADCS6_RPA_slot_ID_4_P0_X : 7|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_4_P0_Y : 9|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_4_P1_X : 27|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_4_P1_Y : 45|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_4_P2_X : 63|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_4_P2_Y : 65|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_4_P3_X : 83|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_4_P3_Y : 101|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_Angle4 : 118|15@0+ (0.001,0) [0|32.767] "rad/s" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_ParkingSlotDepth4 : 135|11@0+ (0.01,0) [0|20.47] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_ParkingSlotWidth4 : 138|11@0+ (0.01,0) [0|20.47] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_4_Status : 155|3@0+ (1,0) [0|7] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_ParkingSlotType4 : 157|2@0+ (1,0) [0|3] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_ParkingSlotDirection4 : 159|2@0+ (1,0) [0|3] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_5_P0_X : 183|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_5_P0_Y : 185|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_5_P1_X : 203|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_5_P1_Y : 221|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_5_P2_X : 239|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_5_P2_Y : 241|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_5_P3_X : 259|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_5_P3_Y : 277|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_Angle5 : 294|15@0+ (0.001,0) [0|32.767] "rad/s" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_ParkingSlotDepth5 : 311|11@0+ (0.01,0) [0|20.47] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_ParkingSlotWidth5 : 314|11@0+ (0.01,0) [0|20.47] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_5_Status : 331|3@0+ (1,0) [0|7] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_ParkingSlotType5 : 333|2@0+ (1,0) [0|3] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_ParkingSlotDirection5 : 335|2@0+ (1,0) [0|3] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_6_P0_X : 359|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_6_P0_Y : 361|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_6_P1_X : 379|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_6_P1_Y : 397|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_6_P2_X : 415|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_6_P2_Y : 417|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_6_P3_X : 435|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_6_P3_Y : 453|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_Angle6 : 470|15@0+ (0.001,0) [0|32.767] "rad/s" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_ParkingSlotDepth6 : 487|11@0+ (0.01,0) [0|20.47] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_ParkingSlotWidth6 : 490|11@0+ (0.01,0) [0|20.47] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_slot_ID_6_Status : 507|3@0+ (1,0) [0|7] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_ParkingSlotType6 : 509|2@0+ (1,0) [0|3] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS6_RPA_ParkingSlotDirection6 : 511|2@0+ (1,0) [0|3] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea

BO_ 402 ADCS_Fr07_192: 64 ADCU_FD3
 SG_ ADCS7_RPA_slot_ID_7_P0_X : 7|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_slot_ID_7_P0_Y : 9|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_slot_ID_7_P1_X : 27|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_slot_ID_7_P1_Y : 45|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_slot_ID_7_P2_X : 63|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_slot_ID_7_P2_Y : 65|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_slot_ID_7_P3_X : 83|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_slot_ID_7_P3_Y : 101|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_slot_Angle7 : 118|15@0+ (0.001,0) [0|32.767] "rad/s" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_ParkingSlotDepth7 : 135|11@0+ (0.01,0) [0|20.47] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_ParkingSlotWidth7 : 138|11@0+ (0.01,0) [0|20.47] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_slot_ID_7_Status : 155|3@0+ (1,0) [0|7] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_ParkingSlotType7 : 157|2@0+ (1,0) [0|3] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_ParkingSlotDirection7 : 159|2@0+ (1,0) [0|3] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_slot_ID_8_P0_X : 183|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_slot_ID_8_P0_Y : 185|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_slot_ID_8_P1_X : 203|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_slot_ID_8_P1_Y : 221|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_slot_ID_8_P2_X : 239|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_slot_ID_8_P2_Y : 241|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_slot_ID_8_P3_X : 259|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_slot_ID_8_P3_Y : 277|14@0+ (0.01,-80) [-80|83.83] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_slot_Angle8 : 294|15@0+ (0.001,0) [0|32.767] "rad/s" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_ParkingSlotDepth8 : 311|11@0+ (0.01,0) [0|20.47] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_ParkingSlotWidth8 : 314|11@0+ (0.01,0) [0|20.47] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_slot_ID_8_Status : 331|3@0+ (1,0) [0|7] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_ParkingSlotType8 : 333|2@0+ (1,0) [0|3] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_ParkingSlotDirection8 : 335|2@0+ (1,0) [0|3] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_PA_ObsDist_F : 487|8@0+ (0.01,0) [0|2.55] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_PA_ObsDist_R : 495|8@0+ (0.01,0) [0|2.55] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_ObsArea : 498|3@0+ (1,0) [0|7] "NoUnit" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS7_RPA_ObsDist : 511|8@0+ (0.01,0) [0|2.55] "m" TBOX,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea

BO_ 403 ADCS_Fr08_193: 64 ADCS_FD3
 SG_ ADCS8_LDWState : 2|3@0+ (1,0) [0|7] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_LDWWarnState : 5|3@0+ (1,0) [0|7] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_lateralCtrHandsEyesOffWarning : 12|3@0+ (1,0) [0|7] "NoUnit" ACU,ICU_E02,GW_FD4,GW_FD1,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_MissingExitAlert : 15|3@0+ (1,0) [0|7] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_LKSSetspeed : 23|8@0+ (1,0) [0|255] "km/h" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_ACCState : 26|3@0+ (1,0) [0|7] "NoUnit" IDB,ESC_FD3,ADCU_FD3,EHB_FD3,CDCS,CDCS_OverSea,ACU,ICU_E02,GW_FD4,GW_FD1,ICU
 SG_ ADCS8_lateralCtrtakeover : 27|1@0+ (1,0) [0|1] "NoUnit" ACU,ICU_E02,GW_FD4,GW_FD1,ICU,GW_FD2,BDCS,CDCS,CDCS_OverSea
 SG_ ADAS8_LateralCtrHandOffReleasewarning : 28|1@0+ (1,0) [0|1] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_longitudCtrlSetSpeed : 39|8@0+ (1,0) [0|255] "km/h" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_NNP_Scenarios : 43|4@0+ (1,0) [0|15] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_longitudCtrlTakeOverReq : 44|1@0+ (1,0) [0|1] "NoUnit" IDB,ESC_FD3,EHB_FD3,CDCS,CDCS_OverSea,ACU,ICU_E02,GW_FD4,GW_FD1,ICU
 SG_ ADCS8_longitudCtrlSetDistance : 47|3@0+ (1,0) [0|7] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_longitudCtrlTargetValidity : 48|1@0+ (1,0) [0|1] "NoUnit" ACU,ICU_E02,GW_FD4,GW_FD1,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_ACCSystemFaultStatus : 50|2@0+ (1,0) [0|3] "NoUnit" IDB,ESC_FD3,EHB_FD3,CDCS,CDCS_OverSea,ACU,ICU_E02,GW_FD4,GW_FD1,ICU
 SG_ ADCS8_AEB_SystemFaultStatus : 53|3@0+ (1,0) [0|7] "NoUnit" IDB,ESC_FD3,EHB_FD3,CDCS,CDCS_OverSea,ACU,ICU_E02,GW_FD4,GW_FD1,ICU
 SG_ ADCS8_AEB_SystemStatus : 55|2@0+ (1,0) [0|3] "NoUnit" IDB,ESC_FD3,ADCU_FD3,EHB_FD3,CDCS,CDCS_OverSea,ACU,ICU_E02,GW_FD4,GW_FD1,ICU
 SG_ ADCS8_FCWSystemFaultStatus : 57|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_FCWStatus : 59|2@0+ (1,0) [0|3] "NoUnit" ADCU_FD3,BDCS,CDCS,CDCS_OverSea,ACU,ICU_E02,GW_FD4,GW_FD1,ICU,GW_FD2
 SG_ ADCS8_FCWSensitiveLevel : 61|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_FCW_State : 63|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_FCTA_State : 65|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_AILampMode : 69|4@0+ (1,0) [0|15] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_CDCS_CertificateState2 : 70|1@0+ (1,0) [0|1] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_FCTA_SystemFaultStatus : 73|2@0+ (1,0) [0|3] "NoUnit" PDCU,ICU_E02,GW_FD4,ICU,GW_FD2,DDCU,CDCS,CDCS_OverSea
 SG_ ADCS8_FCTAWarnObjType : 75|2@0+ (1,0) [0|3] "NoUnit" PDCU,ICU_E02,GW_FD4,ICU,GW_FD2,DDCU,CDCS,CDCS_OverSea
 SG_ ADCS8_FCTARightActiveSt : 77|2@0+ (1,0) [0|3] "NoUnit" PDCU,ICU_E02,GW_FD4,ICU,GW_FD2,BDCS,DDCU,CDCS,CDCS_OverSea
 SG_ ADCS8_FCTALeftActiveSt : 79|2@0+ (1,0) [0|3] "NoUnit" PDCU,ICU_E02,GW_FD4,ICU,GW_FD2,BDCS,DDCU,CDCS,CDCS_OverSea
 SG_ ADCS8_RCTA_SystemFaultStatus : 81|2@0+ (1,0) [0|3] "NoUnit" PDCU,ICU_E02,GW_FD4,ICU,GW_FD2,DDCU,CDCS,CDCS_OverSea
 SG_ ADCS8_RCTARightWarnSt : 83|2@0+ (1,0) [0|3] "NoUnit" PDCU,ICU_E02,GW_FD4,ICU,GW_FD2,BDCS,DDCU,CDCS,CDCS_OverSea
 SG_ ADCS8_RCTALeftWarnSt : 85|2@0+ (1,0) [0|3] "NoUnit" PDCU,ICU_E02,GW_FD4,ICU,GW_FD2,BDCS,DDCU,CDCS,CDCS_OverSea
 SG_ ADCS8_RCTA_State : 87|2@0+ (1,0) [0|3] "NoUnit" PDCU,ICU_E02,GW_FD4,ICU,GW_FD2,DDCU,CDCS,CDCS_OverSea
 SG_ ADCS8_DOW_State : 89|2@0+ (1,0) [0|3] "NoUnit" PDCU,ICU_E02,GW_FD4,ICU,GW_FD2,DDCU,CDCS,CDCS_OverSea
 SG_ ADCS8_RCW_SystemFaultStatus : 91|2@0+ (1,0) [0|3] "NoUnit" PDCU,ICU_E02,GW_FD4,ICU,GW_FD2,DDCU,CDCS,CDCS_OverSea
 SG_ ADCS8_RCW_WarnState : 93|2@0+ (1,0) [0|3] "NoUnit" PDCU,DDCU,CDCS,CDCS_OverSea,ACU,ICU_E02,GW_FD4,GW_FD1,ICU,GW_FD2
 SG_ ADCS8_RCW_State : 95|2@0+ (1,0) [0|3] "NoUnit" PDCU,ICU_E02,GW_FD4,ICU,GW_FD2,DDCU,CDCS,CDCS_OverSea
 SG_ ADCS8_ADAS_IHBCStat : 97|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_DOW_SystemFaultStatus : 99|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_DOWRightWarnState : 101|2@0+ (1,0) [0|3] "NoUnit" PDCU,ICU_E02,GW_FD4,ICU,GW_FD2,BDCS,DDCU,CDCS,CDCS_OverSea
 SG_ ADCS8_DOWLeftWarnState : 103|2@0+ (1,0) [0|3] "NoUnit" PDCU,ICU_E02,GW_FD4,ICU,GW_FD2,BDCS,DDCU,CDCS,CDCS_OverSea
 SG_ ADCS8_LCAState : 105|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_HornReq : 106|1@0+ (1,0) [0|1] "NoUnit" GW_FD2,BDCS
 SG_ ADCS8_DoorUnlock : 107|1@0+ (1,0) [0|1] "NoUnit" PDCU,GW_FD2,BDCS,DDCU
 SG_ ADCS8_ADAS_HazardLampReq : 108|1@0+ (1,0) [0|1] "NoUnit" GW_FD2,BDCS
 SG_ ADCS8_SelfCalibrationReq : 111|3@0+ (1,0) [0|7] "NoUnit" Vector__XXX
 SG_ ADCS8_LCALeftWarnSt : 117|2@0+ (1,0) [0|3] "NoUnit" PDCU,ICU_E02,GW_FD4,ICU,GW_FD2,DDCU,CDCS,CDCS_OverSea
 SG_ ADCS8_LCARightWarnSt : 119|2@0+ (1,0) [0|3] "NoUnit" PDCU,ICU_E02,GW_FD4,ICU,GW_FD2,DDCU,CDCS,CDCS_OverSea
 SG_ ADCS8_TrafficLimitSpeed : 125|6@0+ (1,0) [0|63] "" GW_FD4,CDCS_OverSea
 SG_ ADCS8_ACCOnOffState : 126|1@0+ (1,0) [0|1] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_TSR_SpeedSign : 131|4@0+ (1,0) [0|15] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_TSRState : 133|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_LCASystemFaultStatus : 135|2@0+ (1,0) [0|3] "NoUnit" PDCU,ICU_E02,GW_FD4,ICU,GW_FD2,DDCU,CDCS,CDCS_OverSea
 SG_ ADCS8_TSR_ForbiddenSign : 139|4@0+ (1,0) [0|15] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_NNP_SOAAudioplay : 140|1@0+ (1,0) [0|1] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_TSR_SLFStatefeedback : 142|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_TSR_SpeedWarnState : 143|1@0+ (1,0) [0|1] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_TSR_SystemFaultStatus : 153|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_TSR_StrLightColor : 155|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_TSR_RightLightColor : 157|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_TSR_LeftLightColor : 159|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_VoiceNotifFrequency_mode : 161|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_NPilot_SystemFaultStatus : 164|3@0+ (1,0) [0|7] "NoUnit" ICU_E02,IDB,ESC_FD3,GW_FD4,ICU,EHB_FD3,CDCS,CDCS_OverSea
 SG_ ADCS8_NPilot_SysState : 167|3@0+ (1,0) [0|7] "NoUnit" IDB,ESC_FD3,ADCU_FD3,EHB_FD3,CDCS,CDCS_OverSea,ACU,ICU_E02,GW_FD4,GW_FD1,ICU
 SG_ ADCS8_NNP_AutoOnOffSet : 169|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_NNP_SystemFaultStatus : 172|3@0+ (1,0) [0|7] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_NNPSysState : 175|3@0+ (1,0) [0|7] "NoUnit" ACU,ICU_E02,GW_FD4,GW_FD1,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_DrvOffAlertState : 177|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_DrvOffAlertSwitch : 178|1@0+ (1,0) [0|1] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_FLC_LDWLKA_WarnSetSta : 181|3@0+ (1,0) [0|7] "NoUnit" GW_FD4,CDCS_OverSea
 SG_ ADCS8_DrvOffAlert_SystemFaultStatus : 185|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_Lanechangeinfor : 189|3@0+ (1,0) [0|7] "NoUnit" ICU_E02,GW_FD4,ICU,GW_FD2,BDCS,CDCS,CDCS_OverSea
 SG_ ADCS8_DCLCSysState : 191|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_LaneChangeSystemFaultStatus : 194|3@0+ (1,0) [0|7] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_FLC_RunningState : 199|4@0+ (1,0) [0|15] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_SelfCalibrationProgress : 203|4@0+ (1,0) [0|11] "NoUnit" Vector__XXX
 SG_ ADCS8_LaneChangeWarning : 205|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,GW_FD2,BDCS,CDCS,CDCS_OverSea
 SG_ ADCS8_ISA_TLRwarning : 206|1@0+ (1,0) [0|1] "NoUnit" GW_FD4,CDCS_OverSea
 SG_ ADCS8_FLC_ELKMainState : 210|3@0+ (1,0) [0|7] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_ADAS_DriveOffPossilbe : 211|1@0+ (1,0) [0|1] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_FLC_Fail : 213|2@0+ (1,0) [0|3] "" GW_FD4,CDCS_OverSea
 SG_ ADCS8_SRR_FL_Fail : 215|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_FRS_Fail : 217|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_SRR_RL_Fail : 219|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_DriveOffinhibitionObjType : 222|3@0+ (1,0) [0|7] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_SVC_RL_Fail : 225|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_SVC_FL_Fail : 227|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_SRR_RR_Fail : 229|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_SRR_FR_Fail : 231|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_TSR_OverspeedOnOffSet : 233|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_TrafficSignRecognition : 237|4@0+ (1,0) [0|15] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_RVC_Fail : 239|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_VoiceMode : 240|1@0+ (1,0) [0|1] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_ALC_mode : 241|1@0+ (1,0) [0|1] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_NNP_State : 242|1@0+ (1,0) [0|1] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_FVC_120_Fail : 245|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_Lanechangedirection : 247|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,GW_FD2,BDCS,CDCS,CDCS_OverSea
 SG_ ADCS8_ADSDriving_mode : 249|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_FVC_30_Fail : 251|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_SVC_RR_Fail : 253|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_SVC_FR_Fail : 255|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_NNP_MRM_status : 258|3@0+ (1,0) [0|7] "NoUnit" ICU_E02,GW_FD4,ICU,GW_FD2,BDCS,CDCS,CDCS_OverSea
 SG_ ADCS8_OvertakingAssistSts : 259|1@0+ (1,0) [0|1] "NoUnit" Vector__XXX
 SG_ ADCS8_NpilotOverride_State : 262|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_TSR_ALSUpdataSwfeedback : 263|1@0+ (1,0) [0|1] "NoUnit" GW_FD4,CDCS_OverSea
 SG_ ADCS8_FLC_ELKAcitveType : 266|3@0+ (1,0) [0|7] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_FLC_ELKAMode : 269|3@0+ (1,0) [0|7] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_SystemFault : 271|2@0+ (1,0) [0|3] "NoUnit" ICU_E02,GW_FD4,ICU,CDCS,CDCS_OverSea
 SG_ ADCS8_LeftLidarFault : 273|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_RightlidarFault : 275|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_FLC_ELKAWarnState : 277|2@0+ (1,0) [0|3] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_FLC_TSR_SLWFVoiceSwStatefeedback : 279|2@0+ (1,0) [0|3] "" GW_FD4,CDCS_OverSea
 SG_ ADCS8_NNP_SpeedLimit : 287|8@0+ (1,0) [0|255] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_TSR_LimitOverspeedSet : 295|8@0+ (1,0) [0|100] "%" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_FLC_ISA_SysState : 298|3@0+ (1,0) [0|7] "" GW_FD4,CDCS_OverSea
 SG_ ADCS8_FLC_ELKS_LKAWarnState_LH : 301|3@0+ (1,0) [0|7] "" GW_FD4,CDCS_OverSea
 SG_ ADCS8_FLC_LDWLKA_Recog_SysState : 303|2@0+ (1,0) [0|3] "" GW_FD4,CDCS_OverSea
 SG_ ADCS8_FLC_LDWLKAAid_OnOff_fbk : 306|3@0+ (1,0) [0|7] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_DOWVoiceWarnSt : 308|2@0+ (1,0) [0|3] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_FLC_ELKS_LKAWarnState_RH : 311|3@0+ (1,0) [0|7] "" GW_FD4,CDCS_OverSea
 SG_ ADCS8_Pilot_WorkMod : 313|2@0+ (1,0) [0|3] "NoUnit" Vector__XXX
 SG_ ADCS8_HandShakeSts : 316|3@0+ (1,0) [0|4] "NoUnit" Vector__XXX
 SG_ ADCS8_DCLC_SubStatus : 318|2@0+ (1,0) [0|3] "NoUnit" GW_FD2,BDCS
 SG_ ADCS8_DCLC_SystemSts : 327|2@0+ (1,0) [0|3] "NoUnit" Vector__XXX
 SG_ ADCS8_DCLC_AutChgLane : 325|4@0+ (1,0) [0|6] "NoUnit" Vector__XXX
 SG_ ADCS8_HandsOffWarning : 321|2@0+ (1,0) [0|3] "NoUnit" Vector__XXX
 SG_ ADCS8_FLC_iACC_Status : 343|3@0+ (1,0) [0|7] "NoUnit" Vector__XXX
 SG_ ADCS8_FLC_TSR_ISA_SysState : 340|3@0+ (1,0) [0|7] "NoUnit" GW_FD4,CDCS_OverSea

BO_ 404 ADCS_Fr10_194: 64 ADCU_FD3
 SG_ ADCS8_RPA_CheckListDispReq6 : 0|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_RPA_CheckListDispReq5 : 1|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_RPA_CheckListDispReq4 : 2|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_RPA_CheckListDispReq3 : 3|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_RPA_CheckListDispReq2 : 4|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_RPA_CheckListDispReq1 : 5|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_warninginfo : 15|8@0+ (1,0) [0|255] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrObjWrnngZn_FLM : 18|3@0+ (1,0) [0|7] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrObjWrnngZn_FLC : 21|3@0+ (1,0) [0|7] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_RPA_CheckListDispReq8 : 22|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_RPA_CheckListDispReq7 : 23|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrObjWrnngZn_FRC : 28|3@0+ (1,0) [0|7] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrObjWrnngZn_FRM : 31|3@0+ (1,0) [0|7] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrObjWrnngZn_RLM : 36|3@0+ (1,0) [0|7] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrObjWrnngZn_RLC : 39|3@0+ (1,0) [0|7] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrObjWrnngZn_RRC : 44|3@0+ (1,0) [0|7] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrObjWrnngZn_RRM : 47|3@0+ (1,0) [0|7] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrObjWrnngZn_SFR : 52|3@0+ (1,0) [0|7] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrObjWrnngZn_SFL : 55|3@0+ (1,0) [0|7] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrObjWrnngZn_SRR : 60|3@0+ (1,0) [0|7] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrObjWrnngZn_SRL : 63|3@0+ (1,0) [0|7] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrDist_FLC : 71|8@0+ (1,0) [0|255] "cm" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrDist_FLM : 79|8@0+ (1,0) [0|255] "cm" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrDist_FRM : 87|8@0+ (1,0) [0|255] "cm" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrDist_FRC : 95|8@0+ (1,0) [0|255] "cm" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrDist_RLC : 103|8@0+ (1,0) [0|255] "cm" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrDist_RLM : 111|8@0+ (1,0) [0|255] "cm" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrDist_RRM : 119|8@0+ (1,0) [0|255] "cm" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrDist_RRC : 127|8@0+ (1,0) [0|255] "cm" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrDist_SFL : 135|9@0+ (1,0) [0|511] "cm" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrDist_SFR : 142|9@0+ (1,0) [0|511] "cm" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrDist_SRL : 149|9@0+ (1,0) [0|511] "cm" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrDist_SRR : 156|9@0+ (1,0) [0|511] "cm" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SensorFaultStsFRC : 168|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SensorFaultStsFRM : 169|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SensorFaultStsFLM : 170|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SensorFaultStsFLC : 171|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_RPAS_WorkSts : 173|2@0+ (1,0) [0|3] "NoUnit" FLC_FD3,GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_PA_FPAS_WorkSts : 175|2@0+ (1,0) [0|3] "NoUnit" FLC_FD3,GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_PA_RPAS_SensorFaultStsSRR : 176|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_RPAS_SensorFaultStsSRL : 177|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SensorFaultStsSFR : 178|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SensorFaultStsSFL : 179|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_RPAS_SensorFaultStsRRC : 180|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_RPAS_SensorFaultStsRRM : 181|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_RPAS_SensorFaultStsRLM : 182|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_PA_RPAS_SensorFaultStsRLC : 183|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_AudBpRate_R : 186|3@0+ (1,0) [0|7] "NoUnit" FLC_FD3,GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_AudBpRate_F : 189|3@0+ (1,0) [0|7] "NoUnit" FLC_FD3,GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_AVM_MODWarning : 190|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,GW_FD4,CDCS,CDCS_OverSea,TBOX_OverSea
 SG_ ADCS8_AVM_RomoteAVMFeedBack : 191|1@0+ (1,0) [0|1] "NoUnit" TBOX,FLC_FD3,GW_FD5,TBOX_OverSea
 SG_ ADCS8_PA_FPAS_SnsrObjWrnngZn_RSDW : 194|3@0+ (1,0) [0|7] "NoUnit" FLC_FD3,GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_PA_FPAS_SnsrObjWrnngZn_LSDW : 197|3@0+ (1,0) [0|7] "NoUnit" FLC_FD3,GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_PA_WarningType : 199|2@0+ (1,0) [0|3] "NoUnit" Vector__XXX
 SG_ ADCS8_PA_FPAS_SnsrObjWrnnglc_RSDW : 201|2@0+ (1,0) [0|3] "NoUnit" FLC_FD3,GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_PA_FPAS_SnsrObjWrnnglc_LSDW : 204|2@0+ (1,0) [0|3] "NoUnit" FLC_FD3,GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_Beepreq : 207|3@0+ (1,0) [0|7] "NoUnit" Vector__XXX
 SG_ ADCS8_Mod_Object_MovingDirection : 211|4@0+ (1,0) [0|15] "NoUnit" FLC_FD3,GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS8_TBA_text : 221|6@0+ (1,0) [0|63] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_9_P0_X : 359|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_9_P0_Y : 361|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_9_P1_X : 379|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_9_P1_Y : 397|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_9_P2_X : 415|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_9_P2_Y : 417|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_9_P3_X : 435|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_9_P3_Y : 453|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_Angle9 : 470|15@0+ (0.001,0) [0|32.767] "rad/s" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_ParkingSlotDepth9 : 487|11@0+ (0.01,0) [0|20.47] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_ParkingSlotWidth9 : 490|11@0+ (0.01,0) [0|20.47] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_9_Status : 507|3@0+ (1,0) [0|7] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_ParkingSlotType9 : 509|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_ParkingSlotDirection9 : 511|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea

BO_ 406 ADCS_Fr14_196: 64 ADCU_FD3
 SG_ ADCS5_RPA_slot_ID_10_P0_X : 7|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_10_P0_Y : 9|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_10_P1_X : 27|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_10_P1_Y : 45|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_10_P2_X : 63|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_10_P2_Y : 65|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_10_P3_X : 83|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_10_P3_Y : 101|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_Angle10 : 118|15@0+ (0.001,0) [0|32.767] "rad/s" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_ParkingSlotDepth10 : 135|11@0+ (0.01,0) [0|20.47] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_ParkingSlotWidth10 : 138|11@0+ (0.01,0) [0|20.47] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_10_Status : 155|3@0+ (1,0) [0|7] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_ParkingSlotType10 : 157|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_ParkingSlotDirection10 : 159|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_11_P0_X : 183|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_11_P0_Y : 185|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_11_P1_X : 203|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_11_P1_Y : 221|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_11_P2_X : 239|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_11_P2_Y : 241|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_11_P3_X : 259|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_11_P3_Y : 277|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_Angle11 : 294|15@0+ (0.001,0) [0|32.767] "rad/s" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_ParkingSlotDepth11 : 311|11@0+ (0.01,0) [0|20.47] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_ParkingSlotWidth11 : 314|11@0+ (0.01,0) [0|20.47] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_11_Status : 331|3@0+ (1,0) [0|7] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_ParkingSlotType11 : 333|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_ParkingSlotDirection11 : 335|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_12_P0_X : 359|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_12_P0_Y : 361|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_12_P1_X : 379|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_12_P1_Y : 397|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_12_P2_X : 415|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_12_P2_Y : 417|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_12_P3_X : 435|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_12_P3_Y : 453|14@0+ (0.01,-80) [-80|83.83] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_Angle12 : 470|15@0+ (0.001,0) [0|32.767] "rad/s" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_ParkingSlotDepth12 : 487|11@0+ (0.01,0) [0|20.47] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_ParkingSlotWidth12 : 490|11@0+ (0.01,0) [0|20.47] "m" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_slot_ID_12_Status : 507|3@0+ (1,0) [0|7] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_ParkingSlotType12 : 509|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea
 SG_ ADCS5_RPA_ParkingSlotDirection12 : 511|2@0+ (1,0) [0|3] "NoUnit" GW_FD4,CDCS,CDCS_OverSea

BO_ 460 ADCS_PA_Fr02: 64 ADCS_FD6
 SG_ PA_object_ID1 : 7|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID1_PA_object_Type : 15|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID1_axle_X : 23|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID1_axle_Z : 27|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID1_axle_Y : 47|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID1_Angle : 51|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ PA_object_ID2 : 71|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID2_PA_object_Type : 79|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID2_axle_X : 87|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID2_axle_Z : 91|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID2_axle_Y : 111|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID2_Angle : 115|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ PA_object_ID3 : 135|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID3_PA_object_Type : 143|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID3_axle_X : 151|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID3_axle_Z : 155|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID3_axle_Y : 175|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID3_Angle : 179|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ PA_object_ID4 : 199|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID4_PA_object_Type : 207|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID4_axle_X : 215|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID4_axle_Z : 219|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID4_axle_Y : 239|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID4_Angle : 243|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ PA_object_ID5 : 263|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID5_PA_object_Type : 271|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID5_axle_X : 279|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID5_axle_Z : 283|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID5_axle_Y : 303|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID5_Angle : 307|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ PA_object_ID6 : 327|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID6_PA_object_Type : 335|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID6_axle_X : 343|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID6_axle_Z : 347|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID6_axle_Y : 367|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID6_Angle : 371|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ PA_object_ID7 : 391|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID7_PA_object_Type : 399|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID7_axle_X : 407|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID7_axle_Z : 411|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID7_axle_Y : 431|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID7_Angle : 435|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ PA_object_ID8 : 455|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID8_PA_object_Type : 463|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID8_axle_X : 471|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID8_axle_Z : 475|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID8_axle_Y : 495|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID8_Angle : 499|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea

BO_ 461 ADCS_PA_Fr03: 64 ADCS_FD6
 SG_ PA_object_ID9 : 7|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID9_PA_object_Type : 15|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID9_axle_X : 23|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID9_axle_Z : 27|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID9_axle_Y : 47|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID9_Angle : 51|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ PA_object_ID10 : 71|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID10_PA_object_Type : 79|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID10_axle_X : 87|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID10_axle_Z : 91|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID10_axle_Y : 111|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID10_Angle : 115|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ PA_object_ID11 : 135|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID11_PA_object_Type : 143|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID11_axle_X : 151|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID11_axle_Z : 155|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID11_axle_Y : 175|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID11_Angle : 179|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ PA_object_ID12 : 199|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID12_PA_object_Type : 207|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID12_axle_X : 215|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID12_axle_Z : 219|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID12_axle_Y : 239|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID12_Angle : 243|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ PA_object_ID13 : 263|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID13_PA_object_Type : 271|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID13_axle_X : 279|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID13_axle_Z : 283|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID13_axle_Y : 303|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID13_Angle : 307|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ PA_object_ID14 : 327|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID14_PA_object_Type : 335|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID14_axle_X : 343|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID14_axle_Z : 347|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID14_axle_Y : 367|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID14_Angle : 371|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ PA_object_ID15 : 391|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID15_PA_object_Type : 399|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID15_axle_X : 407|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID15_axle_Z : 411|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID15_axle_Y : 431|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID15_Angle : 435|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ PA_object_ID16 : 455|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID16_PA_object_Type : 463|8@0+ (1,0) [0|255] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID16_axle_X : 471|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID16_axle_Z : 475|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID16_axle_Y : 495|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea
 SG_ ID16_Angle : 499|12@0+ (0.1,-180) [-180|180] "" GW_FD4,CDCS,CDCS_OverSea

BO_TX_BU_ 310 : FLC_ME_FD3,FLC_FD3,ADCS_FD3;
BO_TX_BU_ 400 : ADCU_FD3,ADCS_FD3;
BO_TX_BU_ 401 : ADCU_FD3,ADCS_FD3;
BO_TX_BU_ 402 : ADCU_FD3,ADCS_FD3;
BO_TX_BU_ 403 : ADCS_FD3,FLC_ME_FD3,FLC_FD3;
BO_TX_BU_ 404 : ADCU_FD3,ADCS_FD3;
BO_TX_BU_ 406 : ADCU_FD3,ADCS_FD3;
BO_TX_BU_ 460 : ADCS_FD6,ADCU_FD6;
BO_TX_BU_ 461 : ADCS_FD6,ADCU_FD6;
CM_ BO_ 310 "SSTS-EP32-ADAS行车HMI交互（以最新版本为准）";
CM_ SG_ 310 ADCS12_FCWWarnAudioplay "FCW报警类型语音播报";
CM_ SG_ 310 ADCS12_RCTAWarnAudioplay "RCTA报警类型语音播报";
CM_ SG_ 310 ADCS12_FCTAWarnAudioplay "FCTA报警类型语音播报";
CM_ SG_ 310 ADCS12_SpeedWarnAudioplay "超速语音播报";
CM_ SG_ 310 ADCS12_DOWWarnAudioplay "DOW报警类型语音播报";
CM_ SG_ 310 ADCS12_DCLCAudioplay "DCLC语音播报";
CM_ SG_ 310 ADCS12_PilotAudioPlay "Pilot语音播报";
CM_ SG_ 310 ADCS12_HandOffAudioplay "脱手语音播报";
CM_ SG_ 310 ADCS12_NNPCancelAudioPlay "NNP_cancel语音播报";
CM_ SG_ 310 ADCS12_RCWWarnAudioplay "RCW报警类型语音播报";
CM_ SG_ 310 ADCS12_MRMAudioPlay "MRM语音播报";
CM_ SG_ 310 ADCS12_NNP_ResumeAudioplay "NNP_Resume语音播报";
CM_ SG_ 310 ADCS12_Lcsndrequest "语音变道反馈";
CM_ SG_ 310 ADCS12_Lcsndrconfirm "主动变道驾驶员确认反馈";
CM_ SG_ 310 ADCS12_DriveOffBroadcast "起步提醒播报";
CM_ SG_ 310 ADCS12_EyeOffBroadcast "脱眼语音播报";
CM_ SG_ 310 ADCS12_longitudDisableInfo "不可开启原因";
CM_ SG_ 310 ADCS12_SpeedAdaptComfirm "速度匹配确认反馈信号";
CM_ SG_ 310 ADCS12_PayModeConfirm "收费站匹配确认反馈信号";
CM_ SG_ 310 ADCS12_longitudCtrlSysInfo "HMI文字显示";
CM_ SG_ 310 ADCS12_ADAS_DriveOffinhibition "前车起步抑制请求";
CM_ SG_ 310 ADCS12_P2N_State_Reminder "NNP升降级状态";
CM_ SG_ 310 ADCS12_NNP_State_Reminder "NNP_语音状态提醒";
CM_ SG_ 310 ADCS12_NNP_LightRemind "NNP_语音提示关闭转向灯提醒";
CM_ SG_ 310 ADCS12_LaneChangePendingAlert "变道等待超时提醒";
CM_ SG_ 310 ADCS12_NPilotSysInfo "Npilot信息显示";
CM_ SG_ 310 ADCS12_LCAudioPlay "变道语音提醒";
CM_ SG_ 310 ADCS12_NNP_Scenarios_AudioPlay "NNP所有场景语音提醒";
CM_ SG_ 310 ADCS12_NNP_RINO "NNP进入匝道相关提醒";
CM_ SG_ 400 ADCS5_RPA_slot_ID_1_P0_X "RPA给APP的P0点横坐标1";
CM_ SG_ 400 ADCS5_RPA_slot_ID_1_P0_Y "RPA给APP的P0点纵坐标1";
CM_ SG_ 400 ADCS5_RPA_slot_ID_1_P1_X "RPA给APP的P1点横坐标1";
CM_ SG_ 400 ADCS5_RPA_slot_ID_1_P1_Y "RPA给APP的P1点纵坐标1";
CM_ SG_ 400 ADCS5_RPA_slot_ID_1_P2_X "RPA给APP的P2点横坐标1";
CM_ SG_ 400 ADCS5_RPA_slot_ID_1_P2_Y "RPA给APP的P2点纵坐标1";
CM_ SG_ 400 ADCS5_RPA_slot_ID_1_P3_X "RPA给APP的P3点横坐标1";
CM_ SG_ 400 ADCS5_RPA_slot_ID_1_P3_Y "RPA给APP的P3点纵坐标1";
CM_ SG_ 400 ADCS5_RPA_slot_Angle1 "RPA给APP角度1";
CM_ SG_ 400 ADCS5_RPA_ParkingSlotDepth1 "RPA给APP深度1";
CM_ SG_ 400 ADCS5_RPA_ParkingSlotWidth1 "RPA给APP宽度1";
CM_ SG_ 400 ADCS5_RPA_slot_ID_1_Status "车位ID1状态";
CM_ SG_ 400 ADCS5_RPA_ParkingSlotType1 "RPA给APP类型1";
CM_ SG_ 400 ADCS5_RPA_ParkingSlotDirection1 "RPA给APP方向1";
CM_ SG_ 400 ADCS5_RPA_slot_ID_2_P0_X "RPA给APP的P0点横坐标2";
CM_ SG_ 400 ADCS5_RPA_slot_ID_2_P0_Y "RPA给APP的P0点纵坐标2";
CM_ SG_ 400 ADCS5_RPA_slot_ID_2_P1_X "RPA给APP的P1点横坐标2";
CM_ SG_ 400 ADCS5_RPA_slot_ID_2_P1_Y "RPA给APP的P1点纵坐标2";
CM_ SG_ 400 ADCS5_RPA_slot_ID_2_P2_X "RPA给APP的P2点横坐标2";
CM_ SG_ 400 ADCS5_RPA_slot_ID_2_P2_Y "RPA给APP的P2点纵坐标2";
CM_ SG_ 400 ADCS5_RPA_slot_ID_2_P3_X "RPA给APP的P3点横坐标2";
CM_ SG_ 400 ADCS5_RPA_slot_ID_2_P3_Y "RPA给APP的P3点纵坐标2";
CM_ SG_ 400 ADCS5_RPA_slot_Angle2 "RPA给APP角度2";
CM_ SG_ 400 ADCS5_RPA_ParkingSlotDepth2 "RPA给APP深度2";
CM_ SG_ 400 ADCS5_RPA_ParkingSlotWidth2 "RPA给APP宽度2";
CM_ SG_ 400 ADCS5_RPA_slot_ID_2_Status "车位ID2状态";
CM_ SG_ 400 ADCS5_RPA_ParkingSlotType2 "RPA给APP类型2";
CM_ SG_ 400 ADCS5_RPA_ParkingSlotDirection2 "RPA给APP方向2";
CM_ SG_ 400 ADCS5_RPA_slot_ID_3_P0_X "RPA给APP的P0点横坐标3";
CM_ SG_ 400 ADCS5_RPA_slot_ID_3_P0_Y "RPA给APP的P0点纵坐标3";
CM_ SG_ 400 ADCS5_RPA_slot_ID_3_P1_X "RPA给APP的P1点横坐标3";
CM_ SG_ 400 ADCS5_RPA_slot_ID_3_P1_Y "RPA给APP的P1点纵坐标3";
CM_ SG_ 400 ADCS5_RPA_slot_ID_3_P2_X "RPA给APP的P2点横坐标3";
CM_ SG_ 400 ADCS5_RPA_slot_ID_3_P2_Y "RPA给APP的P2点纵坐标3";
CM_ SG_ 400 ADCS5_RPA_slot_ID_3_P3_X "RPA给APP的P3点横坐标3";
CM_ SG_ 400 ADCS5_RPA_slot_ID_3_P3_Y "RPA给APP的P3点纵坐标3";
CM_ SG_ 400 ADCS5_RPA_slot_Angle3 "RPA给APP角度3";
CM_ SG_ 400 ADCS5_RPA_ParkingSlotDepth3 "RPA给APP深度3";
CM_ SG_ 400 ADCS5_RPA_ParkingSlotWidth3 "RPA给APP宽度3";
CM_ SG_ 400 ADCS5_RPA_slot_ID_3_Status "车位ID3状态";
CM_ SG_ 400 ADCS5_RPA_ParkingSlotType3 "RPA给APP类型3";
CM_ SG_ 400 ADCS5_RPA_ParkingSlotDirection3 "RPA给APP方向3";
CM_ SG_ 401 ADCS6_RPA_slot_ID_4_P0_X "RPA给APP的P0点横坐标4";
CM_ SG_ 401 ADCS6_RPA_slot_ID_4_P0_Y "RPA给APP的P0点纵坐标4";
CM_ SG_ 401 ADCS6_RPA_slot_ID_4_P1_X "RPA给APP的P1点横坐标4";
CM_ SG_ 401 ADCS6_RPA_slot_ID_4_P1_Y "RPA给APP的P1点纵坐标4";
CM_ SG_ 401 ADCS6_RPA_slot_ID_4_P2_X "RPA给APP的P2点横坐标4";
CM_ SG_ 401 ADCS6_RPA_slot_ID_4_P2_Y "RPA给APP的P2点纵坐标4";
CM_ SG_ 401 ADCS6_RPA_slot_ID_4_P3_X "RPA给APP的P3点横坐标4";
CM_ SG_ 401 ADCS6_RPA_slot_ID_4_P3_Y "RPA给APP的P3点纵坐标4";
CM_ SG_ 401 ADCS6_RPA_slot_Angle4 "RPA给APP角度4";
CM_ SG_ 401 ADCS6_RPA_ParkingSlotDepth4 "RPA给APP深度4";
CM_ SG_ 401 ADCS6_RPA_ParkingSlotWidth4 "RPA给APP宽度4";
CM_ SG_ 401 ADCS6_RPA_slot_ID_4_Status "车位ID4状态";
CM_ SG_ 401 ADCS6_RPA_ParkingSlotType4 "RPA给APP类型4";
CM_ SG_ 401 ADCS6_RPA_ParkingSlotDirection4 "RPA给APP方向4";
CM_ SG_ 401 ADCS6_RPA_slot_ID_5_P0_X "RPA给APP的P0点横坐标5";
CM_ SG_ 401 ADCS6_RPA_slot_ID_5_P0_Y "RPA给APP的P0点纵坐标5";
CM_ SG_ 401 ADCS6_RPA_slot_ID_5_P1_X "RPA给APP的P1点横坐标5";
CM_ SG_ 401 ADCS6_RPA_slot_ID_5_P1_Y "RPA给APP的P1点纵坐标5";
CM_ SG_ 401 ADCS6_RPA_slot_ID_5_P2_X "RPA给APP的P2点横坐标5";
CM_ SG_ 401 ADCS6_RPA_slot_ID_5_P2_Y "RPA给APP的P2点纵坐标5";
CM_ SG_ 401 ADCS6_RPA_slot_ID_5_P3_X "RPA给APP的P3点横坐标5";
CM_ SG_ 401 ADCS6_RPA_slot_ID_5_P3_Y "RPA给APP的P3点纵坐标5";
CM_ SG_ 401 ADCS6_RPA_slot_Angle5 "RPA给APP角度5";
CM_ SG_ 401 ADCS6_RPA_ParkingSlotDepth5 "RPA给APP深度5";
CM_ SG_ 401 ADCS6_RPA_ParkingSlotWidth5 "RPA给APP宽度5";
CM_ SG_ 401 ADCS6_RPA_slot_ID_5_Status "车位ID5状态";
CM_ SG_ 401 ADCS6_RPA_ParkingSlotType5 "RPA给APP类型5";
CM_ SG_ 401 ADCS6_RPA_ParkingSlotDirection5 "RPA给APP方向5";
CM_ SG_ 401 ADCS6_RPA_slot_ID_6_P0_X "RPA给APP的P0点横坐标6";
CM_ SG_ 401 ADCS6_RPA_slot_ID_6_P0_Y "RPA给APP的P0点纵坐标6";
CM_ SG_ 401 ADCS6_RPA_slot_ID_6_P1_X "RPA给APP的P1点横坐标6";
CM_ SG_ 401 ADCS6_RPA_slot_ID_6_P1_Y "RPA给APP的P1点纵坐标6";
CM_ SG_ 401 ADCS6_RPA_slot_ID_6_P2_X "RPA给APP的P2点横坐标6";
CM_ SG_ 401 ADCS6_RPA_slot_ID_6_P2_Y "RPA给APP的P2点纵坐标6";
CM_ SG_ 401 ADCS6_RPA_slot_ID_6_P3_X "RPA给APP的P3点横坐标6";
CM_ SG_ 401 ADCS6_RPA_slot_ID_6_P3_Y "RPA给APP的P3点纵坐标6";
CM_ SG_ 401 ADCS6_RPA_slot_Angle6 "RPA给APP角度6";
CM_ SG_ 401 ADCS6_RPA_ParkingSlotDepth6 "RPA给APP深度6";
CM_ SG_ 401 ADCS6_RPA_ParkingSlotWidth6 "RPA给APP宽度6";
CM_ SG_ 401 ADCS6_RPA_slot_ID_6_Status "车位ID6状态";
CM_ SG_ 401 ADCS6_RPA_ParkingSlotType6 "RPA给APP类型6";
CM_ SG_ 401 ADCS6_RPA_ParkingSlotDirection6 "RPA给APP方向6";
CM_ SG_ 402 ADCS7_RPA_slot_ID_7_P0_X "RPA给APP的P0点横坐标7";
CM_ SG_ 402 ADCS7_RPA_slot_ID_7_P0_Y "RPA给APP的P0点纵坐标7";
CM_ SG_ 402 ADCS7_RPA_slot_ID_7_P1_X "RPA给APP的P1点横坐标7";
CM_ SG_ 402 ADCS7_RPA_slot_ID_7_P1_Y "RPA给APP的P1点纵坐标7";
CM_ SG_ 402 ADCS7_RPA_slot_ID_7_P2_X "RPA给APP的P2点横坐标7";
CM_ SG_ 402 ADCS7_RPA_slot_ID_7_P2_Y "RPA给APP的P2点纵坐标7";
CM_ SG_ 402 ADCS7_RPA_slot_ID_7_P3_X "RPA给APP的P3点横坐标7";
CM_ SG_ 402 ADCS7_RPA_slot_ID_7_P3_Y "RPA给APP的P3点纵坐标7";
CM_ SG_ 402 ADCS7_RPA_slot_Angle7 "RPA给APP角度7";
CM_ SG_ 402 ADCS7_RPA_ParkingSlotDepth7 "RPA给APP深度7";
CM_ SG_ 402 ADCS7_RPA_ParkingSlotWidth7 "RPA给APP宽度7";
CM_ SG_ 402 ADCS7_RPA_slot_ID_7_Status "车位ID7状态";
CM_ SG_ 402 ADCS7_RPA_ParkingSlotType7 "RPA给APP类型7";
CM_ SG_ 402 ADCS7_RPA_ParkingSlotDirection7 "RPA给APP方向7";
CM_ SG_ 402 ADCS7_RPA_slot_ID_8_P0_X "RPA给APP的P0点横坐标8";
CM_ SG_ 402 ADCS7_RPA_slot_ID_8_P0_Y "RPA给APP的P0点纵坐标8";
CM_ SG_ 402 ADCS7_RPA_slot_ID_8_P1_X "RPA给APP的P1点横坐标8";
CM_ SG_ 402 ADCS7_RPA_slot_ID_8_P1_Y "RPA给APP的P1点纵坐标8";
CM_ SG_ 402 ADCS7_RPA_slot_ID_8_P2_X "RPA给APP的P2点横坐标8";
CM_ SG_ 402 ADCS7_RPA_slot_ID_8_P2_Y "RPA给APP的P2点纵坐标8";
CM_ SG_ 402 ADCS7_RPA_slot_ID_8_P3_X "RPA给APP的P3点横坐标8";
CM_ SG_ 402 ADCS7_RPA_slot_ID_8_P3_Y "RPA给APP的P3点纵坐标8";
CM_ SG_ 402 ADCS7_RPA_slot_Angle8 "RPA给APP角度8";
CM_ SG_ 402 ADCS7_RPA_ParkingSlotDepth8 "RPA给APP深度8";
CM_ SG_ 402 ADCS7_RPA_ParkingSlotWidth8 "RPA给APP宽度8";
CM_ SG_ 402 ADCS7_RPA_slot_ID_8_Status "车位ID8状态";
CM_ SG_ 402 ADCS7_RPA_ParkingSlotType8 "RPA给APP类型8";
CM_ SG_ 402 ADCS7_RPA_ParkingSlotDirection8 "RPA给APP方向8";
CM_ SG_ 402 ADCS7_PA_ObsDist_F "RPA发送距离车辆前方最近的障碍物距离信息";
CM_ SG_ 402 ADCS7_PA_ObsDist_R "RPA发送距离车辆后方最近的障碍物距离信息";
CM_ SG_ 402 ADCS7_RPA_ObsArea "RPA发送障碍物区域信息";
CM_ SG_ 402 ADCS7_RPA_ObsDist "RPA发送距离车辆最近的障碍物距离信息";
CM_ SG_ 403 ADCS8_LDWState "LDW功能状态";
CM_ SG_ 403 ADCS8_LDWWarnState "LDW报警状态";
CM_ SG_ 403 ADCS8_lateralCtrHandsEyesOffWarning "Hands-off Warning Display";
CM_ SG_ 403 ADCS8_MissingExitAlert "高速或高架路错失出口提醒";
CM_ SG_ 403 ADCS8_LKSSetspeed "LKA激活速度反馈";
CM_ SG_ 403 ADCS8_ACCState "HMI显示";
CM_ SG_ 403 ADCS8_lateralCtrtakeover "驾驶员接管请求";
CM_ SG_ 403 ADAS8_LateralCtrHandOffReleasewarning "HandOffReleasewarning";
CM_ SG_ 403 ADCS8_longitudCtrlSetSpeed "设定速度";
CM_ SG_ 403 ADCS8_NNP_Scenarios "NNP所有场景显示提醒";
CM_ SG_ 403 ADCS8_longitudCtrlTakeOverReq "ADAS纵向控制接管请求";
CM_ SG_ 403 ADCS8_longitudCtrlSetDistance "设定时距";
CM_ SG_ 403 ADCS8_longitudCtrlTargetValidity "是否有目标";
CM_ SG_ 403 ADCS8_ACCSystemFaultStatus "This signal means the ACC system health.";
CM_ SG_ 403 ADCS8_AEB_SystemFaultStatus "AEB状态";
CM_ SG_ 403 ADCS8_AEB_SystemStatus "This signal means indication of AEB On/Off Status";
CM_ SG_ 403 ADCS8_FCWSystemFaultStatus "FCW系统故障";
CM_ SG_ 403 ADCS8_FCWStatus "FCW报警状态";
CM_ SG_ 403 ADCS8_FCWSensitiveLevel "FCW灵敏度反馈";
CM_ SG_ 403 ADCS8_FCW_State "FCW开关状态反馈";
CM_ SG_ 403 ADCS8_FCTA_State "FCTA开关状态反馈";
CM_ SG_ 403 ADCS8_AILampMode "AI灯语显示需求";
CM_ SG_ 403 ADCS8_CDCS_CertificateState2 "PKI证书状态(行车)";
CM_ SG_ 403 ADCS8_FCTA_SystemFaultStatus "FCTA故障状态";
CM_ SG_ 403 ADCS8_FCTAWarnObjType "FCTA报警类型";
CM_ SG_ 403 ADCS8_FCTARightActiveSt "FCTA右报警状态";
CM_ SG_ 403 ADCS8_FCTALeftActiveSt "FCTA左报警状态";
CM_ SG_ 403 ADCS8_RCTA_SystemFaultStatus "RCTA故障状态";
CM_ SG_ 403 ADCS8_RCTARightWarnSt "RCTA右报警状态";
CM_ SG_ 403 ADCS8_RCTALeftWarnSt "RCTA左报警状态";
CM_ SG_ 403 ADCS8_RCTA_State "RCTA开关状态反馈";
CM_ SG_ 403 ADCS8_DOW_State "DOW开关状态反馈";
CM_ SG_ 403 ADCS8_RCW_SystemFaultStatus "RCW故障状态";
CM_ SG_ 403 ADCS8_RCW_WarnState "RCW报警状态";
CM_ SG_ 403 ADCS8_RCW_State "RCW开关状态反馈";
CM_ SG_ 403 ADCS8_ADAS_IHBCStat "IHBC System Option Information";
CM_ SG_ 403 ADCS8_DOW_SystemFaultStatus "DOW故障状态";
CM_ SG_ 403 ADCS8_DOWRightWarnState "DOW Right报警状态（包括前后门）";
CM_ SG_ 403 ADCS8_DOWLeftWarnState "DOW Left报警状态（包括前后门）";
CM_ SG_ 403 ADCS8_LCAState "LCA开关状态反馈";
CM_ SG_ 403 ADCS8_HornReq "请求喇叭响";
CM_ SG_ 403 ADCS8_DoorUnlock "ADCS解锁车门指令";
CM_ SG_ 403 ADCS8_ADAS_HazardLampReq "RCW触发二级报警后，请求报警灯双闪";
CM_ SG_ 403 ADCS8_SelfCalibrationReq "避免用车过程中相机位置偏移，影响行车功能，提示客户从大屏触发相机自标定。";
CM_ SG_ 403 ADCS8_LCALeftWarnSt "LCA（BSD）左报警";
CM_ SG_ 403 ADCS8_LCARightWarnSt "LCA（BSD）右报警";
CM_ SG_ 403 ADCS8_TrafficLimitSpeed "交通限速标识";
CM_ SG_ 403 ADCS8_ACCOnOffState "ADCS巡航开关信号反馈";
CM_ SG_ 403 ADCS8_TSR_SpeedSign "TSR限速标志";
CM_ SG_ 403 ADCS8_TSRState "TSR开关状态反馈";
CM_ SG_ 403 ADCS8_LCASystemFaultStatus "LCA故障状态";
CM_ SG_ 403 ADCS8_TSR_ForbiddenSign "TSR禁止标志";
CM_ SG_ 403 ADCS8_NNP_SOAAudioplay "障碍避让语音提醒";
CM_ SG_ 403 ADCS8_TSR_SLFStatefeedback "智能限速开关";
CM_ SG_ 403 ADCS8_TSR_SpeedWarnState "TSR限速报警";
CM_ SG_ 403 ADCS8_TSR_SystemFaultStatus "TSR故障状态";
CM_ SG_ 403 ADCS8_TSR_StrLightColor "TSR直行信号灯状态";
CM_ SG_ 403 ADCS8_TSR_RightLightColor "TSR右转信号灯状态";
CM_ SG_ 403 ADCS8_TSR_LeftLightColor "TSR左转信号灯状态";
CM_ SG_ 403 ADCS8_VoiceNotifFrequency_mode "导航播报模式反馈";
CM_ SG_ 403 ADCS8_NPilot_SystemFaultStatus "N-Pilot故障状态";
CM_ SG_ 403 ADCS8_NPilot_SysState "N-pilot System State";
CM_ SG_ 403 ADCS8_NNP_AutoOnOffSet "NNP自动开启开关（NNP设置项）";
CM_ SG_ 403 ADCS8_NNP_SystemFaultStatus "NNP故障状态";
CM_ SG_ 403 ADCS8_NNPSysState "NNP系统状态";
CM_ SG_ 403 ADCS8_DrvOffAlertState "起步提醒状态";
CM_ SG_ 403 ADCS8_DrvOffAlertSwitch "起步提醒开关反馈";
CM_ SG_ 403 ADCS8_FLC_LDWLKA_WarnSetSta "车道偏离灵敏度设置反馈";
CM_ SG_ 403 ADCS8_DrvOffAlert_SystemFaultStatus "起步提醒系统故障状态";
CM_ SG_ 403 ADCS8_Lanechangeinfor "Lane change 提醒";
CM_ SG_ 403 ADCS8_DCLCSysState "DCLC开关状态";
CM_ SG_ 403 ADCS8_LaneChangeSystemFaultStatus "变道功能故障";
CM_ SG_ 403 ADCS8_FLC_RunningState "FLC运行模式";
CM_ SG_ 403 ADCS8_SelfCalibrationProgress "通过车机向用户反馈标定进度";
CM_ SG_ 403 ADCS8_LaneChangeWarning "变道危险报警（仪表显示）";
CM_ SG_ 403 ADCS8_ISA_TLRwarning "信号灯识别报警";
CM_ SG_ 403 ADCS8_FLC_ELKMainState "ELK Main State
ELK状态机(FLC-ME平台专用)";
CM_ SG_ 403 ADCS8_ADAS_DriveOffPossilbe "前车起步提醒";
CM_ SG_ 403 ADCS8_FLC_Fail "智能摄像头故障(FLC-ME平台专用)";
CM_ SG_ 403 ADCS8_SRR_FL_Fail "角雷达故障（FL）";
CM_ SG_ 403 ADCS8_FRS_Fail "前雷达故障";
CM_ SG_ 403 ADCS8_SRR_RL_Fail "角雷达故障（RL）";
CM_ SG_ 403 ADCS8_DriveOffinhibitionObjType "起步抑制的目标类型";
CM_ SG_ 403 ADCS8_SVC_RL_Fail "侧视摄像头故障（RL）";
CM_ SG_ 403 ADCS8_SVC_FL_Fail "侧视摄像头故障（FL）";
CM_ SG_ 403 ADCS8_SRR_RR_Fail "角雷达故障（RR）";
CM_ SG_ 403 ADCS8_SRR_FR_Fail "角雷达故障（FR）";
CM_ SG_ 403 ADCS8_TSR_OverspeedOnOffSet "超速报警开关";
CM_ SG_ 403 ADCS8_TrafficSignRecognition "交通标志识别";
CM_ SG_ 403 ADCS8_RVC_Fail "后视摄像头故障";
CM_ SG_ 403 ADCS8_VoiceMode "语音播报模式";
CM_ SG_ 403 ADCS8_ALC_mode "自动变道设置反馈";
CM_ SG_ 403 ADCS8_NNP_State "NNP总开关状态反馈";
CM_ SG_ 403 ADCS8_FVC_120_Fail "120°前视摄像头故障";
CM_ SG_ 403 ADCS8_Lanechangedirection "变道方向提示";
CM_ SG_ 403 ADCS8_ADSDriving_mode "自动驾驶风格选项设置反馈";
CM_ SG_ 403 ADCS8_FVC_30_Fail "30°前视摄像头故障";
CM_ SG_ 403 ADCS8_SVC_RR_Fail "侧视摄像头故障（RR）";
CM_ SG_ 403 ADCS8_SVC_FR_Fail "侧视摄像头故障（FR）";
CM_ SG_ 403 ADCS8_NNP_MRM_status "NNP_MRM（靠边停车）报警";
CM_ SG_ 403 ADCS8_OvertakingAssistSts "超车辅助激活状态";
CM_ SG_ 403 ADCS8_NpilotOverride_State "NPilot_功能暂停";
CM_ SG_ 403 ADCS8_TSR_ALSUpdataSwfeedback "TSR限速更新声音开关反馈";
CM_ SG_ 403 ADCS8_FLC_ELKAcitveType "ELK报警种类(FLC-ME平台专用)";
CM_ SG_ 403 ADCS8_FLC_ELKAMode "ELKA开关状态反馈(FLC-ME平台专用)";
CM_ SG_ 403 ADCS8_SystemFault "ADAS系统故障指示（行车）";
CM_ SG_ 403 ADCS8_LeftLidarFault "左激光雷达故障";
CM_ SG_ 403 ADCS8_RightlidarFault "右激光雷达故障";
CM_ SG_ 403 ADCS8_FLC_ELKAWarnState "ELKA触发时的报警提示(FLC-ME平台专用)";
CM_ SG_ 403 ADCS8_FLC_TSR_SLWFVoiceSwStatefeedback "超速提醒SLWF声音功能设置开关反馈";
CM_ SG_ 403 ADCS8_NNP_SpeedLimit "规控选取的限速值";
CM_ SG_ 403 ADCS8_TSR_LimitOverspeedSet "交通标志识别（TSR）的增加子功能用户可设置限定的超速值进行超速报警提醒";
CM_ SG_ 403 ADCS8_FLC_ISA_SysState "ISA工作模式（非欧盟销售市场产品配置表为TSR）";
CM_ SG_ 403 ADCS8_FLC_ELKS_LKAWarnState_LH "LKA左侧报警";
CM_ SG_ 403 ADCS8_FLC_LDWLKA_Recog_SysState "车道线识别状态";
CM_ SG_ 403 ADCS8_FLC_LDWLKAAid_OnOff_fbk "ELKS（LDW+LKA）
紧急车道保持系统设置反馈";
CM_ SG_ 403 ADCS8_DOWVoiceWarnSt "DOW功能声音报警与视觉报警解耦";
CM_ SG_ 403 ADCS8_FLC_ELKS_LKAWarnState_RH "LKA右侧报警";
CM_ SG_ 403 ADCS8_Pilot_WorkMod "Pilot工作模式信号";
CM_ SG_ 403 ADCS8_HandShakeSts "脱手状态信号";
CM_ SG_ 403 ADCS8_DCLC_SubStatus "DCLC变道状态机信号";
CM_ SG_ 403 ADCS8_DCLC_SystemSts "DCLC父状态";
CM_ SG_ 403 ADCS8_DCLC_AutChgLane "当前DCLC无变道执行状态信号";
CM_ SG_ 403 ADCS8_HandsOffWarning "脱手报警";
CM_ SG_ 403 ADCS8_FLC_iACC_Status "智能限速状态机";
CM_ SG_ 403 ADCS8_FLC_TSR_ISA_SysState "ISA状态机（非欧盟市场产品配置表体现为TSR）";
CM_ SG_ 404 ADCS8_RPA_CheckListDispReq6 "自检条目清单中坡度状态";
CM_ SG_ 404 ADCS8_RPA_CheckListDispReq5 "自检条目清单中胎压状态";
CM_ SG_ 404 ADCS8_RPA_CheckListDispReq4 "自检条目清单中EPB状态";
CM_ SG_ 404 ADCS8_RPA_CheckListDispReq3 "自检条目清单中档位状态";
CM_ SG_ 404 ADCS8_RPA_CheckListDispReq2 "自检条目清单中车速状态";
CM_ SG_ 404 ADCS8_RPA_CheckListDispReq1 "自检条目清单中四门两盖状态";
CM_ SG_ 404 ADCS8_PA_warninginfo "RPA发送工作状态提示信息";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_FLM "左前中目标障碍物报警区域";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_FLC "左前目标障碍物报警区域";
CM_ SG_ 404 ADCS8_RPA_CheckListDispReq8 "自检条目清单中关联系统故障状态";
CM_ SG_ 404 ADCS8_RPA_CheckListDispReq7 "自检条目清单中RPA系统故障状态";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_FRC "右前目标障碍物报警区域";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_FRM "右前中目标障碍物报警区域";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_RLM "左后中目标障碍物报警区域";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_RLC "左后目标障碍物报警区域";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_RRC "右后目标障碍物报警区域";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_RRM "右后中目标障碍物报警区域";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_SFR "右前侧目标障碍物报警区域";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_SFL "左前侧目标障碍物报警区域";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_SRR "右后侧目标障碍物报警区域";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_SRL "左后侧目标障碍物报警区域";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrDist_FLC "左前超声波传感器障碍物距离";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrDist_FLM "左前中超声波传感器障碍物距离";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrDist_FRM "右前中超声波传感器障碍物距离";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrDist_FRC "右前超声波传感器障碍物距离";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrDist_RLC "左后超声波传感器障碍物距离";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrDist_RLM "左后中超声波传感器障碍物距离";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrDist_RRM "右后中超声波传感器障碍物距离";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrDist_RRC "右后超声波传感器障碍物距离";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrDist_SFL "左前侧超声波传感器障碍物距离";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrDist_SFR "右前侧超声波传感器障碍物距离";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrDist_SRL "左后侧超声波传感器障碍物距离";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrDist_SRR "右后侧超声波传感器障碍物距离";
CM_ SG_ 404 ADCS8_PA_FPAS_SensorFaultStsFRC "右前超声波传感器故障";
CM_ SG_ 404 ADCS8_PA_FPAS_SensorFaultStsFRM "右前中超声波传感器故障";
CM_ SG_ 404 ADCS8_PA_FPAS_SensorFaultStsFLM "左前中超声波传感器故障";
CM_ SG_ 404 ADCS8_PA_FPAS_SensorFaultStsFLC "左前超声波传感器故障";
CM_ SG_ 404 ADCS8_PA_RPAS_WorkSts "后超声波工作状态";
CM_ SG_ 404 ADCS8_PA_FPAS_WorkSts "前超声波工作状态";
CM_ SG_ 404 ADCS8_PA_RPAS_SensorFaultStsSRR "右后侧超声波传感器故障";
CM_ SG_ 404 ADCS8_PA_RPAS_SensorFaultStsSRL "左后侧超声波传感器故障";
CM_ SG_ 404 ADCS8_PA_FPAS_SensorFaultStsSFR "右前侧超声波传感器故障";
CM_ SG_ 404 ADCS8_PA_FPAS_SensorFaultStsSFL "左前侧超声波传感器故障";
CM_ SG_ 404 ADCS8_PA_RPAS_SensorFaultStsRRC "右后超声波传感器故障";
CM_ SG_ 404 ADCS8_PA_RPAS_SensorFaultStsRRM "右后中超声波传感器故障";
CM_ SG_ 404 ADCS8_PA_RPAS_SensorFaultStsRLM "左后中超声波传感器故障";
CM_ SG_ 404 ADCS8_PA_RPAS_SensorFaultStsRLC "左后超声波传感器故障";
CM_ SG_ 404 ADCS8_AudBpRate_R "后雷达声音报警频率";
CM_ SG_ 404 ADCS8_AudBpRate_F "前雷达声音报警频率";
CM_ SG_ 404 ADCS8_AVM_MODWarning "MOD报警音";
CM_ SG_ 404 ADCS8_AVM_RomoteAVMFeedBack "AVM远程启动状态反馈";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_RSDW "侧翼保护报警区域信号";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_LSDW "侧翼保护报警区域信号";
CM_ SG_ 404 ADCS8_PA_WarningType "泊车功能人机交互提醒方式反馈";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrObjWrnnglc_RSDW "侧翼保护报警位置信号";
CM_ SG_ 404 ADCS8_PA_FPAS_SnsrObjWrnnglc_LSDW "侧翼保护报警位置信号";
CM_ SG_ 404 ADCS8_Beepreq "泊车beep提醒类型，车机beep提醒和warninginfo及TEXT信号解耦";
CM_ SG_ 404 ADCS8_Mod_Object_MovingDirection "MOD报警方位";
CM_ SG_ 404 ADCS8_TBA_text "循迹倒车提示";
CM_ SG_ 404 ADCS5_RPA_slot_ID_9_P0_X "RPA给APP的P0点横坐标9";
CM_ SG_ 404 ADCS5_RPA_slot_ID_9_P0_Y "RPA给APP的P0点纵坐标9";
CM_ SG_ 404 ADCS5_RPA_slot_ID_9_P1_X "RPA给APP的P1点横坐标9";
CM_ SG_ 404 ADCS5_RPA_slot_ID_9_P1_Y "RPA给APP的P1点纵坐标9";
CM_ SG_ 404 ADCS5_RPA_slot_ID_9_P2_X "RPA给APP的P2点横坐标9";
CM_ SG_ 404 ADCS5_RPA_slot_ID_9_P2_Y "RPA给APP的P2点纵坐标9";
CM_ SG_ 404 ADCS5_RPA_slot_ID_9_P3_X "RPA给APP的P3点横坐标9";
CM_ SG_ 404 ADCS5_RPA_slot_ID_9_P3_Y "RPA给APP的P3点纵坐标9";
CM_ SG_ 404 ADCS5_RPA_slot_Angle9 "RPA给APP角度9";
CM_ SG_ 404 ADCS5_RPA_ParkingSlotDepth9 "RPA给APP深度9";
CM_ SG_ 404 ADCS5_RPA_ParkingSlotWidth9 "RPA给APP宽度9";
CM_ SG_ 404 ADCS5_RPA_slot_ID_9_Status "车位ID9状态";
CM_ SG_ 404 ADCS5_RPA_ParkingSlotType9 "RPA给APP类型9";
CM_ SG_ 404 ADCS5_RPA_ParkingSlotDirection9 "RPA给APP方向9";
CM_ SG_ 406 ADCS5_RPA_slot_ID_10_P0_X "RPA给APP的P0点横坐标10";
CM_ SG_ 406 ADCS5_RPA_slot_ID_10_P0_Y "RPA给APP的P0点纵坐标10";
CM_ SG_ 406 ADCS5_RPA_slot_ID_10_P1_X "RPA给APP的P1点横坐标10";
CM_ SG_ 406 ADCS5_RPA_slot_ID_10_P1_Y "RPA给APP的P1点纵坐标10";
CM_ SG_ 406 ADCS5_RPA_slot_ID_10_P2_X "RPA给APP的P2点横坐标10";
CM_ SG_ 406 ADCS5_RPA_slot_ID_10_P2_Y "RPA给APP的P2点纵坐标10";
CM_ SG_ 406 ADCS5_RPA_slot_ID_10_P3_X "RPA给APP的P3点横坐标10";
CM_ SG_ 406 ADCS5_RPA_slot_ID_10_P3_Y "RPA给APP的P3点纵坐标10";
CM_ SG_ 406 ADCS5_RPA_slot_Angle10 "RPA给APP角度10";
CM_ SG_ 406 ADCS5_RPA_ParkingSlotDepth10 "RPA给APP深度10";
CM_ SG_ 406 ADCS5_RPA_ParkingSlotWidth10 "RPA给APP宽度10";
CM_ SG_ 406 ADCS5_RPA_slot_ID_10_Status "车位ID10状态";
CM_ SG_ 406 ADCS5_RPA_ParkingSlotType10 "RPA给APP类型10";
CM_ SG_ 406 ADCS5_RPA_ParkingSlotDirection10 "RPA给APP方向10";
CM_ SG_ 406 ADCS5_RPA_slot_ID_11_P0_X "RPA给APP的P0点横坐标11";
CM_ SG_ 406 ADCS5_RPA_slot_ID_11_P0_Y "RPA给APP的P0点纵坐标11";
CM_ SG_ 406 ADCS5_RPA_slot_ID_11_P1_X "RPA给APP的P1点横坐标11";
CM_ SG_ 406 ADCS5_RPA_slot_ID_11_P1_Y "RPA给APP的P1点纵坐标11";
CM_ SG_ 406 ADCS5_RPA_slot_ID_11_P2_X "RPA给APP的P2点横坐标11";
CM_ SG_ 406 ADCS5_RPA_slot_ID_11_P2_Y "RPA给APP的P2点纵坐标11";
CM_ SG_ 406 ADCS5_RPA_slot_ID_11_P3_X "RPA给APP的P3点横坐标11";
CM_ SG_ 406 ADCS5_RPA_slot_ID_11_P3_Y "RPA给APP的P3点纵坐标11";
CM_ SG_ 406 ADCS5_RPA_slot_Angle11 "RPA给APP角度11";
CM_ SG_ 406 ADCS5_RPA_ParkingSlotDepth11 "RPA给APP深度11";
CM_ SG_ 406 ADCS5_RPA_ParkingSlotWidth11 "RPA给APP宽度11";
CM_ SG_ 406 ADCS5_RPA_slot_ID_11_Status "车位ID11状态";
CM_ SG_ 406 ADCS5_RPA_ParkingSlotType11 "RPA给APP类型11";
CM_ SG_ 406 ADCS5_RPA_ParkingSlotDirection11 "RPA给APP方向11";
CM_ SG_ 406 ADCS5_RPA_slot_ID_12_P0_X "RPA给APP的P0点横坐标12";
CM_ SG_ 406 ADCS5_RPA_slot_ID_12_P0_Y "RPA给APP的P0点纵坐标12";
CM_ SG_ 406 ADCS5_RPA_slot_ID_12_P1_X "RPA给APP的P1点横坐标12";
CM_ SG_ 406 ADCS5_RPA_slot_ID_12_P1_Y "RPA给APP的P1点纵坐标12";
CM_ SG_ 406 ADCS5_RPA_slot_ID_12_P2_X "RPA给APP的P2点横坐标12";
CM_ SG_ 406 ADCS5_RPA_slot_ID_12_P2_Y "RPA给APP的P2点纵坐标12";
CM_ SG_ 406 ADCS5_RPA_slot_ID_12_P3_X "RPA给APP的P3点横坐标12";
CM_ SG_ 406 ADCS5_RPA_slot_ID_12_P3_Y "RPA给APP的P3点纵坐标12";
CM_ SG_ 406 ADCS5_RPA_slot_Angle12 "RPA给APP角度12";
CM_ SG_ 406 ADCS5_RPA_ParkingSlotDepth12 "RPA给APP深度12";
CM_ SG_ 406 ADCS5_RPA_ParkingSlotWidth12 "RPA给APP宽度12";
CM_ SG_ 406 ADCS5_RPA_slot_ID_12_Status "车位ID12状态";
CM_ SG_ 406 ADCS5_RPA_ParkingSlotType12 "RPA给APP类型12";
CM_ SG_ 406 ADCS5_RPA_ParkingSlotDirection12 "RPA给APP方向12";
CM_ SG_ 460 PA_object_ID1 "泊车目标1";
CM_ SG_ 460 ID1_PA_object_Type "泊车目标1类型";
CM_ SG_ 460 ID1_axle_X "目标1坐标X";
CM_ SG_ 460 ID1_axle_Z "目标1坐标Z";
CM_ SG_ 460 ID1_axle_Y "目标1坐标Y";
CM_ SG_ 460 ID1_Angle "目标1角度";
CM_ SG_ 460 PA_object_ID2 "泊车目标2";
CM_ SG_ 460 ID2_PA_object_Type "泊车目标2类型";
CM_ SG_ 460 ID2_axle_X "目标2坐标X";
CM_ SG_ 460 ID2_axle_Z "目标2坐标Z";
CM_ SG_ 460 ID2_axle_Y "目标2坐标Y";
CM_ SG_ 460 ID2_Angle "目标2角度";
CM_ SG_ 460 PA_object_ID3 "泊车目标3";
CM_ SG_ 460 ID3_PA_object_Type "泊车目标3类型";
CM_ SG_ 460 ID3_axle_X "目标3坐标X";
CM_ SG_ 460 ID3_axle_Z "目标3坐标Z";
CM_ SG_ 460 ID3_axle_Y "目标3坐标Y";
CM_ SG_ 460 ID3_Angle "目标3角度";
CM_ SG_ 460 PA_object_ID4 "泊车目标4";
CM_ SG_ 460 ID4_PA_object_Type "泊车目标4类型";
CM_ SG_ 460 ID4_axle_X "目标4坐标X";
CM_ SG_ 460 ID4_axle_Z "目标4坐标Z";
CM_ SG_ 460 ID4_axle_Y "目标4坐标Y";
CM_ SG_ 460 ID4_Angle "目标4角度";
CM_ SG_ 460 PA_object_ID5 "泊车目标5";
CM_ SG_ 460 ID5_PA_object_Type "泊车目标5类型";
CM_ SG_ 460 ID5_axle_X "目标5坐标X";
CM_ SG_ 460 ID5_axle_Z "目标5坐标Z";
CM_ SG_ 460 ID5_axle_Y "目标5坐标Y";
CM_ SG_ 460 ID5_Angle "目标5角度";
CM_ SG_ 460 PA_object_ID6 "泊车目标6";
CM_ SG_ 460 ID6_PA_object_Type "泊车目标6类型";
CM_ SG_ 460 ID6_axle_X "目标6坐标X";
CM_ SG_ 460 ID6_axle_Z "目标6坐标Z";
CM_ SG_ 460 ID6_axle_Y "目标6坐标Y";
CM_ SG_ 460 ID6_Angle "目标6角度";
CM_ SG_ 460 PA_object_ID7 "泊车目标7";
CM_ SG_ 460 ID7_PA_object_Type "泊车目标7类型";
CM_ SG_ 460 ID7_axle_X "目标7坐标X";
CM_ SG_ 460 ID7_axle_Z "目标7坐标Z";
CM_ SG_ 460 ID7_axle_Y "目标7坐标Y";
CM_ SG_ 460 ID7_Angle "目标7角度";
CM_ SG_ 460 PA_object_ID8 "泊车目标8";
CM_ SG_ 460 ID8_PA_object_Type "泊车目标8类型";
CM_ SG_ 460 ID8_axle_X "目标8坐标X";
CM_ SG_ 460 ID8_axle_Z "目标8坐标Z";
CM_ SG_ 460 ID8_axle_Y "目标8坐标Y";
CM_ SG_ 460 ID8_Angle "目标8角度";
CM_ SG_ 461 PA_object_ID9 "泊车目标9";
CM_ SG_ 461 ID9_PA_object_Type "泊车目标9类型";
CM_ SG_ 461 ID9_axle_X "目标9坐标X";
CM_ SG_ 461 ID9_axle_Z "目标9坐标Z";
CM_ SG_ 461 ID9_axle_Y "目标9坐标Y";
CM_ SG_ 461 ID9_Angle "目标9角度";
CM_ SG_ 461 PA_object_ID10 "泊车目标10";
CM_ SG_ 461 ID10_PA_object_Type "泊车目标10类型";
CM_ SG_ 461 ID10_axle_X "目标10坐标X";
CM_ SG_ 461 ID10_axle_Z "目标10坐标Z";
CM_ SG_ 461 ID10_axle_Y "目标10坐标Y";
CM_ SG_ 461 ID10_Angle "目标10角度";
CM_ SG_ 461 PA_object_ID11 "泊车目标11";
CM_ SG_ 461 ID11_PA_object_Type "泊车目标11类型";
CM_ SG_ 461 ID11_axle_X "目标11坐标X";
CM_ SG_ 461 ID11_axle_Z "目标11坐标Z";
CM_ SG_ 461 ID11_axle_Y "目标11坐标Y";
CM_ SG_ 461 ID11_Angle "目标11角度";
CM_ SG_ 461 PA_object_ID12 "泊车目标12";
CM_ SG_ 461 ID12_PA_object_Type "泊车目标12类型";
CM_ SG_ 461 ID12_axle_X "目标12坐标X";
CM_ SG_ 461 ID12_axle_Z "目标12坐标Z";
CM_ SG_ 461 ID12_axle_Y "目标12坐标Y";
CM_ SG_ 461 ID12_Angle "目标12角度";
CM_ SG_ 461 PA_object_ID13 "泊车目标13";
CM_ SG_ 461 ID13_PA_object_Type "泊车目标13类型";
CM_ SG_ 461 ID13_axle_X "目标13坐标X";
CM_ SG_ 461 ID13_axle_Z "目标13坐标Z";
CM_ SG_ 461 ID13_axle_Y "目标13坐标Y";
CM_ SG_ 461 ID13_Angle "目标13角度";
CM_ SG_ 461 PA_object_ID14 "泊车目标14";
CM_ SG_ 461 ID14_PA_object_Type "泊车目标14类型";
CM_ SG_ 461 ID14_axle_X "目标14坐标X";
CM_ SG_ 461 ID14_axle_Z "目标14坐标Z";
CM_ SG_ 461 ID14_axle_Y "目标14坐标Y";
CM_ SG_ 461 ID14_Angle "目标14角度";
CM_ SG_ 461 PA_object_ID15 "泊车目标15";
CM_ SG_ 461 ID15_PA_object_Type "泊车目标15类型";
CM_ SG_ 461 ID15_axle_X "目标15坐标X";
CM_ SG_ 461 ID15_axle_Z "目标15坐标Z";
CM_ SG_ 461 ID15_axle_Y "目标15坐标Y";
CM_ SG_ 461 ID15_Angle "目标15角度";
CM_ SG_ 461 PA_object_ID16 "泊车目标16";
CM_ SG_ 461 ID16_PA_object_Type "泊车目标16类型";
CM_ SG_ 461 ID16_axle_X "目标16坐标X";
CM_ SG_ 461 ID16_axle_Z "目标16坐标Z";
CM_ SG_ 461 ID16_axle_Y "目标16坐标Y";
CM_ SG_ 461 ID16_Angle "目标16角度";

BA_DEF_ BO_ "CANFD_BRS" ENUM "0","1";
BA_DEF_ BO_ "GenMsgSendType" ENUM "Cycle","NoMsgSendType","IfActive","Event","CA","CE";
BA_DEF_ BO_ "GenMsgNrOfRepetition" INT 0 0;
BA_DEF_ BO_ "GenMsgILSupport" ENUM "No","Yes";
BA_DEF_ BO_ "GenMsgDelayTime" INT 0 0;
BA_DEF_ BO_ "GenMsgCycleTimeFast" INT 0 0;
BA_DEF_ BO_ "GenMsgCycleTime" INT 0 0;
BA_DEF_ BO_ "DiagResponse" ENUM "No","Yes";
BA_DEF_ BO_ "DiagRequest" ENUM "No","Yes";
BA_DEF_ BO_ "NmMessage" ENUM "No","Yes";
BA_DEF_ BO_ "VFrameFormat" ENUM "StandardCAN","ExtendedCAN","reserved","J1939PG","reserved","reserved","reserved","reserved","reserved","reserved","reserved","reserved","reserved","reserved","StandardCAN_FD","ExtendedCAN_FD";
BA_DEF_ SG_ "GenSigInvalidValue" HEX 0 0;
BA_DEF_ SG_ "GenSigStartValue" HEX 0 0;
BA_DEF_ SG_ "GenSigSendType" ENUM "Cycle","OnWrite","OnWriteWithRepetition","OnChange","OnChangeWithRepetition","IfActive","IfActiveWithRepetition","NoSigSendType","vector_leerstring";
BA_DEF_DEF_ "CANFD_BRS" "1";
BA_DEF_DEF_ "GenMsgSendType" "Cycle";
BA_DEF_DEF_ "GenMsgNrOfRepetition" 0;
BA_DEF_DEF_ "GenMsgILSupport" "Yes";
BA_DEF_DEF_ "GenMsgDelayTime" 0;
BA_DEF_DEF_ "GenMsgCycleTimeFast" 0;
BA_DEF_DEF_ "GenMsgCycleTime" 0;
BA_DEF_DEF_ "DiagResponse" "No";
BA_DEF_DEF_ "DiagRequest" "No";
BA_DEF_DEF_ "NmMessage" "No";
BA_DEF_DEF_ "VFrameFormat" "StandardCAN";
BA_DEF_DEF_ "GenSigInvalidValue" 0;
BA_DEF_DEF_ "GenSigStartValue" 0;
BA_DEF_DEF_ "GenSigSendType" "Cycle";
BA_ "GenMsgNrOfRepetition" BO_ 310 3;
BA_ "GenMsgCycleTimeFast" BO_ 310 20;
BA_ "GenMsgSendType" BO_ 310 3;
BA_ "VFrameFormat" BO_ 310 14;
BA_ "GenMsgCycleTime" BO_ 400 50;
BA_ "VFrameFormat" BO_ 400 14;
BA_ "GenMsgCycleTime" BO_ 401 50;
BA_ "VFrameFormat" BO_ 401 14;
BA_ "GenMsgCycleTime" BO_ 402 50;
BA_ "VFrameFormat" BO_ 402 14;
BA_ "GenMsgCycleTime" BO_ 403 50;
BA_ "VFrameFormat" BO_ 403 14;
BA_ "GenMsgCycleTime" BO_ 404 50;
BA_ "VFrameFormat" BO_ 404 14;
BA_ "GenMsgCycleTime" BO_ 406 50;
BA_ "VFrameFormat" BO_ 406 14;
BA_ "GenMsgCycleTime" BO_ 460 50;
BA_ "VFrameFormat" BO_ 460 14;
BA_ "GenMsgCycleTime" BO_ 461 50;
BA_ "VFrameFormat" BO_ 461 14;
BA_ "GenSigSendType" SG_ 310 ADCS12_FCWWarnAudioplay 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_RCTAWarnAudioplay 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_FCTAWarnAudioplay 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_SpeedWarnAudioplay 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_DOWWarnAudioplay 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_DCLCAudioplay 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_PilotAudioPlay 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_HandOffAudioplay 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_NNPCancelAudioPlay 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_RCWWarnAudioplay 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_MRMAudioPlay 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_NNP_ResumeAudioplay 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_Lcsndrequest 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_Lcsndrconfirm 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_DriveOffBroadcast 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_EyeOffBroadcast 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_longitudDisableInfo 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_SpeedAdaptComfirm 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_PayModeConfirm 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_longitudCtrlSysInfo 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_ADAS_DriveOffinhibition 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_P2N_State_Reminder 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_NNP_State_Reminder 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_NNP_LightRemind 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_LaneChangePendingAlert 4;
BA_ "GenSigStartValue" SG_ 310 ADCS12_NPilotSysInfo 31;
BA_ "GenSigSendType" SG_ 310 ADCS12_NPilotSysInfo 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_LCAudioPlay 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_NNP_Scenarios_AudioPlay 4;
BA_ "GenSigSendType" SG_ 310 ADCS12_NNP_RINO 4;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_1_P0_X 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_1_P0_Y 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_1_P1_X 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_1_P1_Y 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_1_P2_X 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_1_P2_Y 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_1_P3_X 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_1_P3_Y 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_Angle1 32767;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_ParkingSlotDepth1 2047;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_ParkingSlotWidth1 2047;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_2_P0_X 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_2_P0_Y 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_2_P1_X 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_2_P1_Y 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_2_P2_X 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_2_P2_Y 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_2_P3_X 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_2_P3_Y 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_Angle2 32767;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_ParkingSlotDepth2 2047;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_ParkingSlotWidth2 2047;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_3_P0_X 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_3_P0_Y 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_3_P1_X 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_3_P1_Y 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_3_P2_X 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_3_P2_Y 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_3_P3_X 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_ID_3_P3_Y 16383;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_slot_Angle3 32767;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_ParkingSlotDepth3 2047;
BA_ "GenSigInvalidValue" SG_ 400 ADCS5_RPA_ParkingSlotWidth3 2047;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_4_P0_X 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_4_P0_Y 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_4_P1_X 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_4_P1_Y 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_4_P2_X 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_4_P2_Y 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_4_P3_X 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_4_P3_Y 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_Angle4 32767;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_ParkingSlotDepth4 2047;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_ParkingSlotWidth4 2047;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_5_P0_X 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_5_P0_Y 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_5_P1_X 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_5_P1_Y 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_5_P2_X 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_5_P2_Y 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_5_P3_X 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_5_P3_Y 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_Angle5 32767;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_ParkingSlotDepth5 2047;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_ParkingSlotWidth5 2047;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_6_P0_X 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_6_P0_Y 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_6_P1_X 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_6_P1_Y 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_6_P2_X 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_6_P2_Y 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_6_P3_X 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_ID_6_P3_Y 16383;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_slot_Angle6 32767;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_ParkingSlotDepth6 2047;
BA_ "GenSigInvalidValue" SG_ 401 ADCS6_RPA_ParkingSlotWidth6 2047;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_slot_ID_7_P0_X 16383;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_slot_ID_7_P0_Y 16383;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_slot_ID_7_P1_X 16383;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_slot_ID_7_P1_Y 16383;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_slot_ID_7_P2_X 16383;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_slot_ID_7_P2_Y 16383;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_slot_ID_7_P3_X 16383;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_slot_ID_7_P3_Y 16383;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_slot_Angle7 32767;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_ParkingSlotDepth7 2047;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_ParkingSlotWidth7 2047;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_slot_ID_8_P0_X 16383;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_slot_ID_8_P0_Y 16383;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_slot_ID_8_P1_X 16383;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_slot_ID_8_P1_Y 16383;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_slot_ID_8_P2_X 16383;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_slot_ID_8_P2_Y 16383;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_slot_ID_8_P3_X 16383;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_slot_ID_8_P3_Y 16383;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_slot_Angle8 32767;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_ParkingSlotDepth8 2047;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_ParkingSlotWidth8 2047;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_PA_ObsDist_F 255;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_PA_ObsDist_R 255;
BA_ "GenSigInvalidValue" SG_ 402 ADCS7_RPA_ObsDist 255;
BA_ "GenSigStartValue" SG_ 403 ADCS8_LKSSetspeed 55;
BA_ "GenSigStartValue" SG_ 403 ADCS8_ACCState 1;
BA_ "GenSigStartValue" SG_ 403 ADCS8_longitudCtrlSetSpeed 30;
BA_ "GenSigStartValue" SG_ 403 ADCS8_longitudCtrlSetDistance 3;
BA_ "GenSigStartValue" SG_ 403 ADCS8_AEB_SystemStatus 1;
BA_ "GenSigStartValue" SG_ 403 ADCS8_FCTA_State 2;
BA_ "GenSigStartValue" SG_ 403 ADCS8_CDCS_CertificateState2 1;
BA_ "GenSigStartValue" SG_ 403 ADCS8_RCTA_State 2;
BA_ "GenSigStartValue" SG_ 403 ADCS8_DOW_State 2;
BA_ "GenSigStartValue" SG_ 403 ADCS8_RCW_State 2;
BA_ "GenSigStartValue" SG_ 403 ADCS8_LCAState 2;
BA_ "GenSigStartValue" SG_ 403 ADCS8_TSRState 2;
BA_ "GenSigStartValue" SG_ 403 ADCS8_DrvOffAlertSwitch 1;
BA_ "GenSigStartValue" SG_ 403 ADCS8_TSR_OverspeedOnOffSet 1;
BA_ "GenSigStartValue" SG_ 403 ADCS8_ADSDriving_mode 1;
BA_ "GenSigStartValue" SG_ 403 ADCS8_NpilotOverride_State 1;
BA_ "GenSigStartValue" SG_ 403 ADCS8_TSR_LimitOverspeedSet 255;
BA_ "GenSigInvalidValue" SG_ 404 ADCS8_PA_FPAS_SnsrDist_FLC 255;
BA_ "GenSigInvalidValue" SG_ 404 ADCS8_PA_FPAS_SnsrDist_FLM 255;
BA_ "GenSigInvalidValue" SG_ 404 ADCS8_PA_FPAS_SnsrDist_FRM 255;
BA_ "GenSigInvalidValue" SG_ 404 ADCS8_PA_FPAS_SnsrDist_FRC 255;
BA_ "GenSigInvalidValue" SG_ 404 ADCS8_PA_FPAS_SnsrDist_RLC 255;
BA_ "GenSigInvalidValue" SG_ 404 ADCS8_PA_FPAS_SnsrDist_RLM 255;
BA_ "GenSigInvalidValue" SG_ 404 ADCS8_PA_FPAS_SnsrDist_RRM 255;
BA_ "GenSigInvalidValue" SG_ 404 ADCS8_PA_FPAS_SnsrDist_RRC 255;
BA_ "GenSigInvalidValue" SG_ 404 ADCS8_PA_FPAS_SnsrDist_SFL 511;
BA_ "GenSigInvalidValue" SG_ 404 ADCS8_PA_FPAS_SnsrDist_SFR 511;
BA_ "GenSigInvalidValue" SG_ 404 ADCS8_PA_FPAS_SnsrDist_SRL 511;
BA_ "GenSigInvalidValue" SG_ 404 ADCS8_PA_FPAS_SnsrDist_SRR 511;
BA_ "GenSigStartValue" SG_ 404 ADCS8_PA_RPAS_WorkSts 1;
BA_ "GenSigStartValue" SG_ 404 ADCS8_PA_FPAS_WorkSts 1;
BA_ "GenSigInvalidValue" SG_ 404 ADCS5_RPA_slot_ID_9_P0_X 16383;
BA_ "GenSigInvalidValue" SG_ 404 ADCS5_RPA_slot_ID_9_P0_Y 16383;
BA_ "GenSigInvalidValue" SG_ 404 ADCS5_RPA_slot_ID_9_P1_X 16383;
BA_ "GenSigInvalidValue" SG_ 404 ADCS5_RPA_slot_ID_9_P1_Y 16383;
BA_ "GenSigInvalidValue" SG_ 404 ADCS5_RPA_slot_ID_9_P2_X 16383;
BA_ "GenSigInvalidValue" SG_ 404 ADCS5_RPA_slot_ID_9_P2_Y 16383;
BA_ "GenSigInvalidValue" SG_ 404 ADCS5_RPA_slot_ID_9_P3_X 16383;
BA_ "GenSigInvalidValue" SG_ 404 ADCS5_RPA_slot_ID_9_P3_Y 16383;
BA_ "GenSigInvalidValue" SG_ 404 ADCS5_RPA_slot_Angle9 32767;
BA_ "GenSigInvalidValue" SG_ 404 ADCS5_RPA_ParkingSlotDepth9 2047;
BA_ "GenSigInvalidValue" SG_ 404 ADCS5_RPA_ParkingSlotWidth9 2047;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_10_P0_X 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_10_P0_Y 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_10_P1_X 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_10_P1_Y 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_10_P2_X 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_10_P2_Y 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_10_P3_X 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_10_P3_Y 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_Angle10 32767;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_ParkingSlotDepth10 2047;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_ParkingSlotWidth10 2047;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_11_P0_X 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_11_P0_Y 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_11_P1_X 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_11_P1_Y 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_11_P2_X 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_11_P2_Y 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_11_P3_X 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_11_P3_Y 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_Angle11 32767;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_ParkingSlotDepth11 2047;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_ParkingSlotWidth11 2047;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_12_P0_X 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_12_P0_Y 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_12_P1_X 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_12_P1_Y 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_12_P2_X 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_12_P2_Y 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_12_P3_X 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_ID_12_P3_Y 16383;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_slot_Angle12 32767;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_ParkingSlotDepth12 2047;
BA_ "GenSigInvalidValue" SG_ 406 ADCS5_RPA_ParkingSlotWidth12 2047;
BA_ "GenSigStartValue" SG_ 460 ID1_axle_X 1800;
BA_ "GenSigStartValue" SG_ 460 ID1_axle_Z 1800;
BA_ "GenSigStartValue" SG_ 460 ID1_axle_Y 1800;
BA_ "GenSigStartValue" SG_ 460 ID1_Angle 1800;
BA_ "GenSigStartValue" SG_ 460 ID2_axle_X 1800;
BA_ "GenSigStartValue" SG_ 460 ID2_axle_Z 1800;
BA_ "GenSigStartValue" SG_ 460 ID2_axle_Y 1800;
BA_ "GenSigStartValue" SG_ 460 ID2_Angle 1800;
BA_ "GenSigStartValue" SG_ 460 ID3_axle_X 1800;
BA_ "GenSigStartValue" SG_ 460 ID3_axle_Z 1800;
BA_ "GenSigStartValue" SG_ 460 ID3_axle_Y 1800;
BA_ "GenSigStartValue" SG_ 460 ID3_Angle 1800;
BA_ "GenSigStartValue" SG_ 460 ID4_axle_X 1800;
BA_ "GenSigStartValue" SG_ 460 ID4_axle_Z 1800;
BA_ "GenSigStartValue" SG_ 460 ID4_axle_Y 1800;
BA_ "GenSigStartValue" SG_ 460 ID4_Angle 1800;
BA_ "GenSigStartValue" SG_ 460 ID5_axle_X 1800;
BA_ "GenSigStartValue" SG_ 460 ID5_axle_Z 1800;
BA_ "GenSigStartValue" SG_ 460 ID5_axle_Y 1800;
BA_ "GenSigStartValue" SG_ 460 ID5_Angle 1800;
BA_ "GenSigStartValue" SG_ 460 ID6_axle_X 1800;
BA_ "GenSigStartValue" SG_ 460 ID6_axle_Z 1800;
BA_ "GenSigStartValue" SG_ 460 ID6_axle_Y 1800;
BA_ "GenSigStartValue" SG_ 460 ID6_Angle 1800;
BA_ "GenSigStartValue" SG_ 460 ID7_axle_X 1800;
BA_ "GenSigStartValue" SG_ 460 ID7_axle_Z 1800;
BA_ "GenSigStartValue" SG_ 460 ID7_axle_Y 1800;
BA_ "GenSigStartValue" SG_ 460 ID7_Angle 1800;
BA_ "GenSigStartValue" SG_ 460 ID8_axle_X 1800;
BA_ "GenSigStartValue" SG_ 460 ID8_axle_Z 1800;
BA_ "GenSigStartValue" SG_ 460 ID8_axle_Y 1800;
BA_ "GenSigStartValue" SG_ 460 ID8_Angle 1800;
BA_ "GenSigStartValue" SG_ 461 ID9_axle_X 1800;
BA_ "GenSigStartValue" SG_ 461 ID9_axle_Z 1800;
BA_ "GenSigStartValue" SG_ 461 ID9_axle_Y 1800;
BA_ "GenSigStartValue" SG_ 461 ID9_Angle 1800;
BA_ "GenSigStartValue" SG_ 461 ID10_axle_X 1800;
BA_ "GenSigStartValue" SG_ 461 ID10_axle_Z 1800;
BA_ "GenSigStartValue" SG_ 461 ID10_axle_Y 1800;
BA_ "GenSigStartValue" SG_ 461 ID10_Angle 1800;
BA_ "GenSigStartValue" SG_ 461 ID11_axle_X 1800;
BA_ "GenSigStartValue" SG_ 461 ID11_axle_Z 1800;
BA_ "GenSigStartValue" SG_ 461 ID11_axle_Y 1800;
BA_ "GenSigStartValue" SG_ 461 ID11_Angle 1800;
BA_ "GenSigStartValue" SG_ 461 ID12_axle_X 1800;
BA_ "GenSigStartValue" SG_ 461 ID12_axle_Z 1800;
BA_ "GenSigStartValue" SG_ 461 ID12_axle_Y 1800;
BA_ "GenSigStartValue" SG_ 461 ID12_Angle 1800;
BA_ "GenSigStartValue" SG_ 461 ID13_axle_X 1800;
BA_ "GenSigStartValue" SG_ 461 ID13_axle_Z 1800;
BA_ "GenSigStartValue" SG_ 461 ID13_axle_Y 1800;
BA_ "GenSigStartValue" SG_ 461 ID13_Angle 1800;
BA_ "GenSigStartValue" SG_ 461 ID14_axle_X 1800;
BA_ "GenSigStartValue" SG_ 461 ID14_axle_Z 1800;
BA_ "GenSigStartValue" SG_ 461 ID14_axle_Y 1800;
BA_ "GenSigStartValue" SG_ 461 ID14_Angle 1800;
BA_ "GenSigStartValue" SG_ 461 ID15_axle_X 1800;
BA_ "GenSigStartValue" SG_ 461 ID15_axle_Z 1800;
BA_ "GenSigStartValue" SG_ 461 ID15_axle_Y 1800;
BA_ "GenSigStartValue" SG_ 461 ID15_Angle 1800;
BA_ "GenSigStartValue" SG_ 461 ID16_axle_X 1800;
BA_ "GenSigStartValue" SG_ 461 ID16_axle_Z 1800;
BA_ "GenSigStartValue" SG_ 461 ID16_axle_Y 1800;
BA_ "GenSigStartValue" SG_ 461 ID16_Angle 1800;
VAL_ 310 ADCS12_FCWWarnAudioplay 1 "Warning Play" 0 "None";
VAL_ 310 ADCS12_RCTAWarnAudioplay 2 "Right Warning play" 1 "Left Warning play" 0 "None";
VAL_ 310 ADCS12_FCTAWarnAudioplay 2 "Right Warning play" 1 "Left Warning play" 0 "None";
VAL_ 310 ADCS12_SpeedWarnAudioplay 1 "Warning Play" 0 "None";
VAL_ 310 ADCS12_DOWWarnAudioplay 1 "Warning Play" 0 "None";
VAL_ 310 ADCS12_DCLCAudioplay 7 "Alert 4 broadcast" 6 "Alert 3 broadcast" 5 "Alert 2 broadcast" 4 "Alert 1 broadcast" 3 "Cancel broadcast" 2 "right broadcast" 1 "Left broadcast" 0 "None";
VAL_ 310 ADCS12_PilotAudioPlay 3 "Pilot cancel" 2 "Pilot resumed" 1 "Pilot Override" 0 "None";
VAL_ 310 ADCS12_HandOffAudioplay 3 "EM takeover broadcast" 2 "takeover braodcast" 1 "Handsoff warning broadcast" 0 "None";
VAL_ 310 ADCS12_NNPCancelAudioPlay 1 "NNP Cancel play" 0 "None";
VAL_ 310 ADCS12_RCWWarnAudioplay 1 "Warning Play" 0 "None";
VAL_ 310 ADCS12_MRMAudioPlay 3 "Finish broadcast" 2 "EM Warning broadcast" 1 "MRM Warning broadcast" 0 "None";
VAL_ 310 ADCS12_NNP_ResumeAudioplay 2 "Resume reminder" 1 "Suspended" 0 "None";
VAL_ 310 ADCS12_Lcsndrequest 1 "Request inactive" 0 "Request active";
VAL_ 310 ADCS12_Lcsndrconfirm 1 "Confirm inactive" 0 "Confirm active";
VAL_ 310 ADCS12_DriveOffBroadcast 1 "Requested" 0 "No Request";
VAL_ 310 ADCS12_EyeOffBroadcast 1 "Broadcast request" 0 "None";
VAL_ 310 ADCS12_longitudDisableInfo 15 "reason 4" 14 "reason 3" 13 "reason 2" 12 "reason 1" 11 "竞速模式" 10 "开关未开" 9 "无法开启" 8 "底盘(预留)" 7 "EPB拉起" 6 "前舱盖" 5 "后备箱" 4 "door open" 3 "seatbelt untied" 2 "braking" 1 "speed not satisfied" 0 "None";
VAL_ 310 ADCS12_SpeedAdaptComfirm 1 "request" 0 "No request";
VAL_ 310 ADCS12_PayModeConfirm 1 "Request" 0 "No request";
VAL_ 310 ADCS12_longitudCtrlSysInfo 11 "override提示" 10 "ACC lost arbitration" 9 "ACC is cancelled" 8 "Display HDC Request" 7 "Display Takeover Request" 6 "Display Disable to engage ACC" 5 "Display ACC disengaged" 4 "Display Available to resume acceleration control" 3 "Display Object disappeared" 2 "Display  ACC fault unavaliable" 1 "Display ACC on" 0 "Default";
VAL_ 310 ADCS12_ADAS_DriveOffinhibition 1 "Requested" 0 "No Request";
VAL_ 310 ADCS12_P2N_State_Reminder 7 "NNP unable to active by sound" 6 "degrad to Pilot Reminder" 5 "NNP Pre-degrade Reminder II" 4 "NNP Pre-degrade Reminder" 3 "NNP Active Reminder" 2 "Pilot pre-upgrade Reminder II" 1 "Pilot Pre-upgrade Reminder" 0 "No";
VAL_ 310 ADCS12_NNP_State_Reminder 7 "NNP_fault reminder" 6 "NNP dropped-out" 5 "NNP Pre-cancel Reminder III" 4 "NNP Pre-cancel Reminder II" 3 "NNP Pre-cancel Reminder" 2 "NNP activated Reminder" 1 "NNP ready to activate Reminder" 0 "No";
VAL_ 310 ADCS12_NNP_LightRemind 1 "Light not off" 0 "Not Used";
VAL_ 310 ADCS12_LaneChangePendingAlert 1 "Request" 0 "No Request";
VAL_ 310 ADCS12_NPilotSysInfo 31 "Default" 30 "Reserved" 29 "Reserved" 28 "Reserved" 27 "Reserved" 26 "Reserved" 25 "Reserved" 24 "Reserved" 23 "Reserved" 22 "Reserved" 21 "reason 5" 20 "reason 4" 19 "reason 3" 18 "reason 2" 17 "reason 1" 16 "开关关闭" 15 "不在ODD内" 14 "GPS信号差" 13 "无法开启" 12 "Racing mode" 11 "EPB拉起" 10 "前舱盖" 9 "后备箱" 8 "door open" 7 "reservedseatbelt untied" 6 "Disable to engage NPilot Cuz lane" 5 "Disable to engage NPilot Cuz braking" 4 "Disable to engage NPilot Cuz speed" 3 "Disable to engage NPilot cuz fault" 2 "NPilot Off" 1 "NPilot On" 0 "Disable to engage NPilot";
VAL_ 310 ADCS12_LCAudioPlay 2 "Right LaneChange active" 1 "Left Lane Change active" 0 "None";
VAL_ 310 ADCS12_NNP_Scenarios_AudioPlay 11 "Best Path Tracing" 10 "Oncoming Vehicle" 9 "Oversized Vehicle One Side" 8 "Oversized Vehicle Both Side" 7 "SpeedAdapt" 6 "Narrow Lane" 5 "Lane  Reduce" 4 "PayModeConfirm" 3 "Pedastrian Walk" 2 "TFL" 1 "Static Obstacle" 0 "None";
VAL_ 310 ADCS12_NNP_RINO 7 "Exit Missed" 6 "Navigation Task Take Over Request" 5 "Ramp Out DONE" 4 "Ramp Out Start" 3 "Ramp Out Heavy Traffic" 2 "Ramp In DONE" 1 "Ramp In Start" 0 "No Request";
VAL_ 400 ADCS5_RPA_slot_ID_1_Status 7 "Reserved" 6 "Reserved" 5 "Reserved" 4 "Unknown" 3 "Selected" 2 "Unavailable" 1 "Available" 0 "default";
VAL_ 400 ADCS5_RPA_ParkingSlotType1 3 "Oblique" 2 "Parallel" 1 "Vertical" 0 "Undecided";
VAL_ 400 ADCS5_RPA_ParkingSlotDirection1 2 "Right" 1 "Left" 0 "No";
VAL_ 400 ADCS5_RPA_slot_ID_2_Status 7 "Reserved" 6 "Reserved" 5 "Reserved" 4 "Unknown" 3 "Selected" 2 "Unavailable" 1 "Available" 0 "default";
VAL_ 400 ADCS5_RPA_ParkingSlotType2 3 "Oblique" 2 "Parallel" 1 "Vertical" 0 "Undecided";
VAL_ 400 ADCS5_RPA_ParkingSlotDirection2 2 "Right" 1 "Left" 0 "No";
VAL_ 400 ADCS5_RPA_slot_ID_3_Status 7 "Reserved" 6 "Reserved" 5 "Reserved" 4 "Unknown" 3 "Selected" 2 "Unavailable" 1 "Available" 0 "default";
VAL_ 400 ADCS5_RPA_ParkingSlotType3 3 "Oblique" 2 "Parallel" 1 "Vertical" 0 "Undecided";
VAL_ 400 ADCS5_RPA_ParkingSlotDirection3 2 "Right" 1 "Left" 0 "No";
VAL_ 401 ADCS6_RPA_slot_ID_4_Status 7 "Reserved" 6 "Reserved" 5 "Reserved" 4 "Unknown" 3 "Selected" 2 "Unavailable" 1 "Available" 0 "default";
VAL_ 401 ADCS6_RPA_ParkingSlotType4 3 "Oblique" 2 "Parallel" 1 "Vertical" 0 "Undecided";
VAL_ 401 ADCS6_RPA_ParkingSlotDirection4 2 "Right" 1 "Left" 0 "No";
VAL_ 401 ADCS6_RPA_slot_ID_5_Status 7 "Reserved" 6 "Reserved" 5 "Reserved" 4 "Unknown" 3 "Selected" 2 "Unavailable" 1 "Available" 0 "default";
VAL_ 401 ADCS6_RPA_ParkingSlotType5 3 "Oblique" 2 "Parallel" 1 "Vertical" 0 "Undecided";
VAL_ 401 ADCS6_RPA_ParkingSlotDirection5 2 "Right" 1 "Left" 0 "No";
VAL_ 401 ADCS6_RPA_slot_ID_6_Status 7 "Reserved" 6 "Reserved" 5 "Reserved" 4 "Unknown" 3 "Selected" 2 "Unavailable" 1 "Available" 0 "default";
VAL_ 401 ADCS6_RPA_ParkingSlotType6 3 "Oblique" 2 "Parallel" 1 "Vertical" 0 "Undecided";
VAL_ 401 ADCS6_RPA_ParkingSlotDirection6 2 "Right" 1 "Left" 0 "No";
VAL_ 402 ADCS7_RPA_slot_ID_7_Status 7 "Reserved" 6 "Reserved" 5 "Reserved" 4 "Unknown" 3 "Selected" 2 "Unavailable" 1 "Available" 0 "default";
VAL_ 402 ADCS7_RPA_ParkingSlotType7 3 "Oblique" 2 "Parallel" 1 "Vertical" 0 "undecided";
VAL_ 402 ADCS7_RPA_ParkingSlotDirection7 2 "Right" 1 "Left" 0 "No";
VAL_ 402 ADCS7_RPA_slot_ID_8_Status 7 "Reserved" 6 "Reserved" 5 "Reserved" 4 "Unknown" 3 "Selected" 2 "Unavailable" 1 "Available" 0 "default";
VAL_ 402 ADCS7_RPA_ParkingSlotType8 3 "Oblique" 2 "Parallel" 1 "Vertical" 0 "Undecided";
VAL_ 402 ADCS7_RPA_ParkingSlotDirection8 2 "Right" 1 "Left" 0 "No";
VAL_ 402 ADCS7_RPA_ObsArea 4 "Right" 3 "Left" 2 "Rear" 1 "Front" 0 "No object";
VAL_ 403 ADCS8_LDWState 7 "Reserved" 6 "Reserved" 5 "Reserved" 4 "LDW passive" 3 "LDW Fail" 2 "LDW Active" 1 "LDW Standby" 0 "Off";
VAL_ 403 ADCS8_LDWWarnState 5 "Reserved" 4 "Right Warning leve2" 3 "Right Warning leve1" 2 "Left Warning leve2" 1 "Left Warning leve1" 0 "No Warning";
VAL_ 403 ADCS8_lateralCtrHandsEyesOffWarning 3 "eyes off Warning" 2 "Automatic-Off Warning(Display)" 1 "Hands-off Warning(Display)" 0 "No Warning";
VAL_ 403 ADCS8_MissingExitAlert 3 "Reserved" 2 "Exit Missed" 1 "Navigation Task Take Over Request" 0 "No Warning";
VAL_ 403 ADCS8_ACCState 7 "Passive" 6 "Fault" 5 "Standstill Wait" 4 "Standstill Active" 3 "Override" 2 "Active" 1 "Standby" 0 "Off";
VAL_ 403 ADCS8_lateralCtrtakeover 1 "Requested" 0 "No request";
VAL_ 403 ADAS8_LateralCtrHandOffReleasewarning 1 "Requested" 0 "No request";
VAL_ 403 ADCS8_NNP_Scenarios 11 "Best Path Tracing" 10 "Oncoming Vehicle" 9 "Oversized Vehicle One Side" 8 "Oversized Vehicle Both Side" 7 "SpeedAdapt" 6 "Narrow Lane" 5 "Lane  Reduce" 4 "PayModeConfirm" 3 "Pedastrian Walk" 2 "TFL" 1 "Static Obstacle" 0 "None";
VAL_ 403 ADCS8_longitudCtrlTakeOverReq 1 "Requested" 0 "No Request";
VAL_ 403 ADCS8_longitudCtrlSetDistance 7 "Reserved2" 6 "Reserved1" 5 "Level#5" 4 "Level#4" 3 "Level#3" 2 "Level#2" 1 "Level#1" 0 "No time gap set";
VAL_ 403 ADCS8_longitudCtrlTargetValidity 1 "Valid target vehicle" 0 "No target vehicle";
VAL_ 403 ADCS8_ACCSystemFaultStatus 3 "Service Required" 2 "System Temporary Unvailable" 1 "Performance Degradation" 0 "No Error";
VAL_ 403 ADCS8_AEB_SystemFaultStatus 3 "Service Required" 2 "System Temporary Unvailable" 1 "Performance Degradation" 0 "No Error";
VAL_ 403 ADCS8_AEB_SystemStatus 1 "On" 0 "Off";
VAL_ 403 ADCS8_FCWSystemFaultStatus 3 "Service required" 2 "System temperary unavailable" 1 "Performance degrade" 0 "No error";
VAL_ 403 ADCS8_FCWStatus 3 "Reserved" 2 "Warning level2" 1 "Warning level1" 0 "No request";
VAL_ 403 ADCS8_FCWSensitiveLevel 2 "Early" 1 "Normal" 0 "Late";
VAL_ 403 ADCS8_FCW_State 1 "On" 0 "Off";
VAL_ 403 ADCS8_FCTA_State 1 "On" 0 "Off";
VAL_ 403 ADCS8_AILampMode 15 "Reserved" 14 "Reserved" 13 "GreenRightTurn" 12 "GreenLeftTurn" 11 "GreenBreathing" 10 "GreenBlinkIntermittent" 9 "GreenBlink1Hz" 8 "RedBlink2Hz" 7 "RedBink1Hz" 6 "YellowBli" 5 "BlueStayON" 4 "BlueRightTurn2Hz" 3 "BlueRightTurn1Hz" 2 "BlueLeftTurn2Hz" 1 "BlueLeftTurn1Hz" 0 "Default";
VAL_ 403 ADCS8_CDCS_CertificateState2 1 "有效" 0 "无效";
VAL_ 403 ADCS8_FCTA_SystemFaultStatus 3 "Service required" 2 "System temperary unavailable" 1 "Performance degrade" 0 "No error";
VAL_ 403 ADCS8_FCTAWarnObjType 3 "Reserved" 2 "Unknown" 1 "Vehicle" 0 "No Object";
VAL_ 403 ADCS8_FCTARightActiveSt 3 "Reserved" 2 "Level 2" 1 "Level 1" 0 "No Warning";
VAL_ 403 ADCS8_FCTALeftActiveSt 3 "Reserved" 2 "Level 2" 1 "Level 1" 0 "No Warning";
VAL_ 403 ADCS8_RCTA_SystemFaultStatus 3 "Service required" 2 "System temperary unavailable" 1 "Performance degrade" 0 "No error";
VAL_ 403 ADCS8_RCTARightWarnSt 3 "Reserved" 2 "Level 2" 1 "Level 1" 0 "No Warning";
VAL_ 403 ADCS8_RCTALeftWarnSt 3 "Reserved" 2 "Level 2" 1 "Level 1" 0 "No Warning";
VAL_ 403 ADCS8_RCTA_State 1 "On" 0 "Off";
VAL_ 403 ADCS8_DOW_State 1 "On" 0 "Off";
VAL_ 403 ADCS8_RCW_SystemFaultStatus 3 "Service required" 2 "System temperary unavailable" 1 "Performance degrade" 0 "No error";
VAL_ 403 ADCS8_RCW_WarnState 3 "Reserved" 2 "Level 2" 1 "Level 1" 0 "No Warning";
VAL_ 403 ADCS8_RCW_State 1 "On" 0 "Off";
VAL_ 403 ADCS8_ADAS_IHBCStat 1 "On" 0 "Off";
VAL_ 403 ADCS8_DOW_SystemFaultStatus 3 "Service required" 2 "System temperary unavailable" 1 "Performance degrade" 0 "No error";
VAL_ 403 ADCS8_DOWRightWarnState 3 "Level 3" 2 "Level 2" 1 "Level 1" 0 "No Warning";
VAL_ 403 ADCS8_DOWLeftWarnState 3 "Level 3" 2 "Level 2" 1 "Level 1" 0 "No Warning";
VAL_ 403 ADCS8_LCAState 1 "On" 0 "Off";
VAL_ 403 ADCS8_HornReq 1 "Request" 0 "No Request";
VAL_ 403 ADCS8_DoorUnlock 1 "Requested" 0 "No Request";
VAL_ 403 ADCS8_ADAS_HazardLampReq 1 "Request" 0 "No Request";
VAL_ 403 ADCS8_SelfCalibrationReq 7 "reserved" 6 "reserved" 5 "reserved" 4 "reserved" 3 "reserved" 2 "reserved" 1 "Self-calibration required." 0 "No action";
VAL_ 403 ADCS8_LCALeftWarnSt 3 "Reserved" 2 "LV2 Warning(LCA)" 1 "LV1 Warning(BSD)" 0 "No warning";
VAL_ 403 ADCS8_LCARightWarnSt 3 "Reserved" 2 "LV2 Warning(LCA)" 1 "LV1 Warning(BSD)" 0 "No warning";
VAL_ 403 ADCS8_TrafficLimitSpeed 63 "Reserved" 62 "Reserved" 61 "Reserved" 60 "Reserved" 59 "Reserved" 58 "Reserved" 57 "Reserved" 56 "Reserved" 55 "Reserved" 54 "Reserved" 53 "Reserved" 52 "Reserved" 51 "Reserved" 50 "Reserved" 49 "Reserved" 48 "Reserved" 47 "Reserved" 46 "Reserved" 45 "Reserved" 44 "Reserved" 43 "Reserved" 42 "Reserved" 41 "Reserved" 40 "Reserved" 39 "Reserved" 38 "无限速要求区域" 37 "超过限速180" 36 "SPL 180" 35 "SPL 175" 34 "SPL 170" 33 "SPL 165" 32 "SPL 160" 31 "SPL 155" 30 "SPL 150" 29 "SPL 145" 28 "SPL 140" 27 "SPL 135" 26 "SPL 130" 25 "SPL 125" 24 "SPL 120" 23 "SPL 115" 22 "SPL 110" 21 "SPL 105" 20 "SPL 100" 19 "SPL 95" 18 "SPL 90" 17 "SPL 85" 16 "SPL 80" 15 "SPL 75" 14 "SPL 70" 13 "SPL 65" 12 "SPL 60" 11 "SPL 55" 10 "SPL 50" 9 "SPL 45" 8 "SPL 40" 7 "SPL 35" 6 "SPL 30" 5 "SPL 25" 4 "SPL 20" 3 "SPL 15" 2 "SPL 10" 1 "SPL 5" 0 "no traffic limit speed";
VAL_ 403 ADCS8_ACCOnOffState 1 "On" 0 "Off";
VAL_ 403 ADCS8_TSR_SpeedSign 15 "限速120km/h" 14 "限速110km/h" 13 "限速100km/h" 12 "限速90km/h" 11 "限速80km/h" 10 "限速70km/h" 9 "限速60km/h" 8 "限速50km/h" 7 "限速40km/h" 6 "限速35km/h" 5 "限速30km/h" 4 "限速20km/h" 3 "限速15km/h" 2 "限速10km/h" 1 "限速5km/h" 0 "No traffic limit speed";
VAL_ 403 ADCS8_TSRState 1 "On" 0 "Off";
VAL_ 403 ADCS8_LCASystemFaultStatus 3 "Service required" 2 "System temperary unavailable" 1 "Performance degrade" 0 "No error";
VAL_ 403 ADCS8_TSR_ForbiddenSign 15 "Reserved" 14 "Reserved" 13 "Reserved" 12 "Reserved" 11 "Reserved" 10 "Reserved" 9 "Reserved" 8 "No passing（禁止通行）" 7 "No turning back（禁止掉头）" 6 "No entry（禁止驶入）" 5 "No parking（禁止停车）" 4 "No turning（禁止转弯）" 3 "No straight（禁止直行）" 2 "No turning right（禁止右转）" 1 "No turning left（禁止左转）" 0 "No sign";
VAL_ 403 ADCS8_NNP_SOAAudioplay 1 "SOA Audiobroadcast" 0 "None";
VAL_ 403 ADCS8_TSR_SLFStatefeedback 1 "On" 0 "Off";
VAL_ 403 ADCS8_TSR_SpeedWarnState 1 "Warning" 0 "No Warning";
VAL_ 403 ADCS8_TSR_SystemFaultStatus 3 "Service required" 2 "System temperary unavailable" 1 "Performance degrade" 0 "No error";
VAL_ 403 ADCS8_TSR_StrLightColor 3 "Green" 2 "Yellow" 1 "Red" 0 "No signal";
VAL_ 403 ADCS8_TSR_RightLightColor 3 "Green" 2 "Yellow" 1 "Red" 0 "No signal";
VAL_ 403 ADCS8_TSR_LeftLightColor 3 "Green" 2 "Yellow" 1 "Red" 0 "No signal";
VAL_ 403 ADCS8_VoiceNotifFrequency_mode 2 "Detailed" 1 "Simple" 0 "Basic";
VAL_ 403 ADCS8_NPilot_SystemFaultStatus 3 "Service Required" 2 "System Temporary Unvailable" 1 "Performance Degradation" 0 "No Error";
VAL_ 403 ADCS8_NPilot_SysState 5 "passive" 4 "Fault" 3 "suspend" 2 "Active" 1 "Standby" 0 "OFF";
VAL_ 403 ADCS8_NNP_AutoOnOffSet 1 "On" 0 "Off";
VAL_ 403 ADCS8_NNP_SystemFaultStatus 3 "Service Required" 2 "System Temporary Unvailable" 1 "Performance Degradation" 0 "No Error";
VAL_ 403 ADCS8_NNPSysState 7 "Map limited" 6 "Fault" 5 "Pilot" 4 "Suspend" 3 "TO_transition" 2 "Active" 1 "standby" 0 "Off and not avaliable and Passive";
VAL_ 403 ADCS8_DrvOffAlertState 3 "reserved" 2 "DrvOff Traffic light" 1 "DrvOff Object" 0 "Inactive";
VAL_ 403 ADCS8_DrvOffAlertSwitch 1 "ON" 0 "OFF";
VAL_ 403 ADCS8_FLC_LDWLKA_WarnSetSta 7 "Reserved" 6 "Reserved" 5 "Reserved" 4 "Reserved" 3 "Early" 2 "Normal" 1 "Late" 0 "Not Applied";
VAL_ 403 ADCS8_DrvOffAlert_SystemFaultStatus 3 "Service Required" 2 "System Temporary unavailable" 1 "Performance Degradation" 0 "No Error";
VAL_ 403 ADCS8_Lanechangeinfor 7 "solid lane type" 6 "Lane change ongoing" 5 "Lane change pending" 4 "Lane change cancel" 3 "Lane change end" 2 "Lane change start" 1 "Vehicle Speed too low" 0 "None";
VAL_ 403 ADCS8_DCLCSysState 1 "On" 0 "Off";
VAL_ 403 ADCS8_LaneChangeSystemFaultStatus 3 "Service Required" 2 "System Temporary Unvailable" 1 "Performance Degradation" 0 "No Error";
VAL_ 403 ADCS8_FLC_RunningState 15 "Reserved" 14 "Reserved" 13 "Reserved" 12 "Reserved" 11 "Reserved" 10 "Reserved" 9 "Reserved" 8 "Reserved" 7 "Reserved" 6 "Reserved" 5 "Reserved" 4 "Reserved" 3 "Reserved" 2 "Reserved" 1 "Low-power consumption Mode" 0 "Normal Mode";
VAL_ 403 ADCS8_SelfCalibrationProgress 11 "100%" 10 "90%" 9 "80%" 8 "70%" 7 "60%" 6 "50%" 5 "40%" 4 "30%" 3 "20%" 2 "10%" 1 "0%" 0 "No request";
VAL_ 403 ADCS8_LaneChangeWarning 3 "Reserved" 2 "Right Warning" 1 "Left Warning" 0 "No Warning";
VAL_ 403 ADCS8_ISA_TLRwarning 1 "Request" 0 "No Request";
VAL_ 403 ADCS8_FLC_ELKMainState 7 "Reserved" 6 "Reserved" 5 "Reserved" 4 "ELK Failure" 3 "ELK Active" 2 "ELK Standby" 1 "ELK Passive" 0 "ELK OFF";
VAL_ 403 ADCS8_ADAS_DriveOffPossilbe 1 "Requested" 0 "No Request";
VAL_ 403 ADCS8_FLC_Fail 2 "FLC Fault" 1 "Blocked" 0 "Normal";
VAL_ 403 ADCS8_SRR_FL_Fail 2 "Radar Fault" 1 "Radar Blocked" 0 "Radar is Working";
VAL_ 403 ADCS8_FRS_Fail 2 "Radar Fault" 1 "Radar Blocked" 0 "Radar is Working";
VAL_ 403 ADCS8_SRR_RL_Fail 2 "Radar Fault" 1 "Radar Blocked" 0 "Radar is Working";
VAL_ 403 ADCS8_DriveOffinhibitionObjType 4 "Unknown" 3 "Cyelist" 2 "Vehicle" 1 "Pedestrian" 0 "No Object";
VAL_ 403 ADCS8_SVC_RL_Fail 2 "Sensor Fault" 1 "Blocked" 0 "Normal";
VAL_ 403 ADCS8_SVC_FL_Fail 2 "Sensor Fault" 1 "Blocked" 0 "Normal";
VAL_ 403 ADCS8_SRR_RR_Fail 2 "Radar Fault" 1 "Radar Blocked" 0 "Radar is Working";
VAL_ 403 ADCS8_SRR_FR_Fail 2 "Radar Fault" 1 "Radar Blocked" 0 "Radar is Working";
VAL_ 403 ADCS8_TSR_OverspeedOnOffSet 1 "On" 0 "Off";
VAL_ 403 ADCS8_TrafficSignRecognition 7 "Yield_sigh让行" 6 "Stop_sign停止" 5 "No_Enter_sign禁止驶入" 4 "No_turn_around_sign禁止调头" 3 "No_turn_sign 禁止转弯" 2 "No_right_turn_sign禁止右转" 1 "No_left_turn_sign禁止左转" 0 "No traffic sign recognition";
VAL_ 403 ADCS8_RVC_Fail 2 "Sensor Fault" 1 "Blocked" 0 "Normal";
VAL_ 403 ADCS8_VoiceMode 1 "More tips" 0 "Simple";
VAL_ 403 ADCS8_ALC_mode 1 "Automated LC" 0 "Voice allowed LC + Lever allowed LC";
VAL_ 403 ADCS8_NNP_State 1 "ON（开启）" 0 "OFF（关闭）";
VAL_ 403 ADCS8_FVC_120_Fail 3 "Over temp" 2 "Sensor Fault" 1 "Blocked" 0 "Normal";
VAL_ 403 ADCS8_Lanechangedirection 2 "right" 1 "left" 0 "None";
VAL_ 403 ADCS8_ADSDriving_mode 3 "Radical" 2 "Normal" 1 "Basic";
VAL_ 403 ADCS8_FVC_30_Fail 2 "Sensor Fault" 1 "Blocked" 0 "Normal";
VAL_ 403 ADCS8_SVC_RR_Fail 2 "Sensor Fault" 1 "Blocked" 0 "Normal";
VAL_ 403 ADCS8_SVC_FR_Fail 2 "Sensor Fault" 1 "Blocked" 0 "Normal";
VAL_ 403 ADCS8_NNP_MRM_status 4 "Stand&Warning" 3 "Finshied" 2 "MRM Ongoing" 1 "EM Ongoing" 0 "No";
VAL_ 403 ADCS8_OvertakingAssistSts 1 "active" 0 "inactive";
VAL_ 403 ADCS8_NpilotOverride_State 3 "Not used" 2 "Resumed" 1 "Overriding" 0 "No";
VAL_ 403 ADCS8_TSR_ALSUpdataSwfeedback 1 "ON" 0 "OFF";
VAL_ 403 ADCS8_FLC_ELKAcitveType 7 "Reserved" 6 "Reserved" 5 "Reserved" 4 "Solid Line" 3 "Road Edge" 2 "Overtaking" 1 "Oncomming" 0 "No Active";
VAL_ 403 ADCS8_FLC_ELKAMode 3 "reserved" 2 "OFF" 1 "ON" 0 "No action";
VAL_ 403 ADCS8_SystemFault 3 "reserved" 2 "Service Required" 1 "System temporary Unavaliable" 0 "System Normal";
VAL_ 403 ADCS8_LeftLidarFault 2 "Sensor Fault" 1 "Blocked" 0 "Normal";
VAL_ 403 ADCS8_RightlidarFault 2 "Sensor Fault" 1 "Blocked" 0 "Normal";
VAL_ 403 ADCS8_FLC_ELKAWarnState 3 "Reserved" 2 "Right Warning" 1 "Left Warning" 0 "No Warning";
VAL_ 403 ADCS8_FLC_TSR_SLWFVoiceSwStatefeedback 3 "Reseved" 2 "ON" 1 "OFF" 0 "NO action";
VAL_ 403 ADCS8_NNP_SpeedLimit 0 "No traffic limit speed";
VAL_ 403 ADCS8_TSR_LimitOverspeedSet 255 "No Action";
VAL_ 403 ADCS8_FLC_ISA_SysState 7 "Reserved" 6 "Reserved" 5 "Reserved" 4 "Reserved" 3 "Reserved" 2 "Fusion Mode" 1 "Navigation Mode" 0 "Vision Mode";
VAL_ 403 ADCS8_FLC_ELKS_LKAWarnState_LH 6 "Reserved" 5 "Reserved" 4 "Reserved" 3 "level3 (纠偏+声音长鸣报警）" 2 "level2 (纠偏+声音报警）" 1 "level1（仅纠偏）" 0 "no warning";
VAL_ 403 ADCS8_FLC_LDWLKA_Recog_SysState 3 "Both Line Recognition" 2 "Right Line Recognition" 1 "Left Line Recognition" 0 "No Recognition";
VAL_ 403 ADCS8_FLC_LDWLKAAid_OnOff_fbk 7 "Reserved" 6 "Reserved" 5 "Reserved" 4 "LKA" 3 "LDW+LKA" 2 "LDW" 1 "OFF" 0 "No Request";
VAL_ 403 ADCS8_DOWVoiceWarnSt 3 "Reserved" 2 "Level 2" 1 "Level 1" 0 "No Warning";
VAL_ 403 ADCS8_FLC_ELKS_LKAWarnState_RH 6 "Reserved" 5 "Reserved" 4 "Reserved" 3 "level3 (纠偏+声音长鸣报警）" 2 "level2 (纠偏+声音报警）" 1 "level1（仅纠偏）" 0 "no warning";
VAL_ 403 ADCS8_Pilot_WorkMod 3 "FollowMode" 2 "LCCMode" 1 "ACCMode" 0 "OFF";
VAL_ 403 ADCS8_HandShakeSts 4 "Reserved" 3 "Invalid" 2 "Hands-on" 1 "Hands-off" 0 "No Detection";
VAL_ 403 ADCS8_DCLC_SubStatus 3 "Active" 2 "Standby" 1 "Passive" 0 "Inactive";
VAL_ 403 ADCS8_DCLC_SystemSts 3 "Reserved" 2 "Failure" 1 "ON" 0 "off";
VAL_ 403 ADCS8_DCLC_AutChgLane 6 "Cancel" 5 "Success" 4 "Right Change Lane Ongoing" 3 "Left Change Lane Ongoing" 2 "Right Change Lane Waiting" 1 "Left Change Lane Waiting" 0 "No Active";
VAL_ 403 ADCS8_HandsOffWarning 3 "reserved" 2 "Level 2 Warning" 1 "Level 1 Warning" 0 "No Warning";
VAL_ 403 ADCS8_FLC_iACC_Status 7 "Reserved" 6 "Reserved" 5 "Reserved" 4 "Fault" 3 "Active" 2 "Standby" 1 "Passive" 0 "Off";
VAL_ 403 ADCS8_FLC_TSR_ISA_SysState 7 "Reserved" 6 "Reserved" 5 "Reserved" 4 "Fault" 3 "Active" 2 "Standby" 1 "Passive" 0 "Off";
VAL_ 404 ADCS8_RPA_CheckListDispReq6 1 "Not Satisfied" 0 "Slope is satisfied";
VAL_ 404 ADCS8_RPA_CheckListDispReq5 1 "Not Satisfied" 0 "Tire Pressure is satisfied";
VAL_ 404 ADCS8_RPA_CheckListDispReq4 1 "Not Satisfied" 0 "EPB is satisfied";
VAL_ 404 ADCS8_RPA_CheckListDispReq3 1 "Not Satisfied" 0 "Gear Conditions are satisfied";
VAL_ 404 ADCS8_RPA_CheckListDispReq2 1 "Not Satisfied" 0 "Vehicle is stanstill";
VAL_ 404 ADCS8_RPA_CheckListDispReq1 1 "Not Satisfied" 0 "Doors are all closed";
VAL_ 404 ADCS8_PA_warninginfo 96 "安全带未系，记忆泊车即将退出" 95 "坡度过大，记忆泊车暂不可用" 94 "检测到溜车,记忆泊车即将退出" 93 "环境异常,记忆泊车即将退出" 92 "车辆受阻,记忆泊车即将退出" 91 "坡度过大，记忆泊车即将退出" 90 "泊车超速，记忆泊车即将退出" 89 "发生碰撞，记忆泊车即将退出" 88 "EPB干预，记忆泊车即将退出" 87 "关联系统受限，功能无法开启" 86 "请在地下停车场使用记忆泊车" 85 "Reserved" 84 "松开刹车后，继续记忆泊车" 83 "请先挂D挡" 82 "请从地面回到地库，再开始学习" 81 "请保持车辆静止" 80 "记忆泊车暂不可用（笼统提示）" 79 "请立即接管车辆" 78 "请不要加速" 77 "记忆泊车即将退出（笼统提示）" 76 "关联系统受限，功能即将退出" 75 "系统受限，功能即将退出" 74 "用户干预挡位，记忆泊车即将退出" 73 "用户干预方向盘，记忆泊车即将退出" 72 "我没学会，重新再试试吧" 71 "关联系统受限，路线学习失败" 70 "系统受限，路线学习失败" 69 "车辆掉头，路线学习失败" 68 "倒车行驶，路线学习失败" 67 "坡度过大，路线学习失败" 66 "已超过最大学习里程，路线学习失败" 65 "速度过快，路线学习失败" 64 "路线重叠，路线学习失败" 63 "机舱盖打开，路线学习失败" 62 "行李箱打开，路线学习失败" 61 "车门打开，路线学习失败" 60 "遥控设备电量低" 59 "操作超时，请接管车辆" 58 "无法预期完成泊车，请稍后再试" 57 "请踩住刹车再选择车位" 56 "请在60s内连接蓝牙" 55 "车位搜索超时，功能中止，3s后退出" 54 "记忆泊?已暂停，请在30s内返回??继续泊?（手机）" 53 "导航地图不可用（手机）,功能无法开启" 52 "与车辆距离过远（手机）,功能无法开启" 51 "GPS或手机信号异常（手机）,功能无法开启" 50 "GPS或手机信号异常，功能终止，请前往处理" 49 "非封闭园区（手机）,功能无法开启" 48 "非停车场区域，功能无法开启" 47 "环境异常，功能终止，3S后退出（车端）/请前往处理（手机）" 46 "道路信息无法满足路线学习要求，记忆泊车已退出，已学习路线将删除" 45 "车辆掉头，记忆泊车已退出，已学习路线将删除" 44 "车辆受阻，功能终止，3S后退出（车端）/请前往处理（手机）" 43 "发生碰撞，功能终止，3S后退出（车端）/请前往处理（手机）" 42 "地图创建失败，功能终止，3S后退出（车端）/请前往处理（手机）" 41 "移动网络通讯差，功能终止，3S后退出（车端）/请前往处理（手机）" 40 "初始化定位失败，功能终止，3S后退出（车端）/请前往处理（手机）" 39 "路线学习失败，记忆泊车已退出，已学习路线将删除" 38 "系统错误，记忆泊车已退出，已学习路线将删除" 37 "泊车失败，记忆泊车已退出，已学习路线将删除" 36 "位置信息丢失，记忆泊车已退出，已学习路线将删除" 35 "跨层受限，记忆泊车已退出，已学习路线将删除" 34 "环境异常，记忆泊车已退出，已学习路线将删除" 33 "挂入R档，记忆泊车已退出，已学习路线将删除" 32 "已超过最大学习里程，记忆泊车已退出，已学习路线将删除" 31 "机舱盖打开，记忆泊车已退出，已学习路线将删除" 30 "行李箱打开，记忆泊车已退出，已学习路线将删除" 29 "车门打开，记忆泊车已退出，已学习路线将删除" 28 "胎压报警，功能终止，3S后退出（车端）/请前往处理（手机）" 27 "功能终止，系统3S后退出（车端）/请前往处理（手机）" 26 "遥控泊车按键松开，泊车暂停" 25 "蓝牙连接故障，请连接蓝牙后重试" 24 "后视镜被折叠，功能终止，3S后退出（车端）/请前往处理（手机）" 23 "泊车空间不足，功能终止，3S后退出（车端）/请前往处理（手机" 22 "电量不足，功能终止，3S后退出（车端）/请前往处理（手机）" 21 "雨量过大，功能终止，3S后退出（车端）/请前往处理（手机）" 20 "坡度过大，功能终止，3S后退出（车端）/请前往处理（手机）" 19 "NNP功能激活，功能终止，3S后退出（车端）/请前往处理（手机）" 18 "驾驶员干预，功能终止，3S后退出（车端）/请前往处理（手机）" 17 "泊车超步，功能终止，3S后退出（车端）/请前往处理（手机）" 16 "泊车超时，功能终止，3S后退出（车端）/请前往处理（手机）" 15 "泊车超速，功能终止，3S后退出（车端）/请前往处理（手机）" 14 "泊车系统故障，功能终止，3S后退出（车端）/请前往处理（手机）" 13 "关联系统故障，功能终止，3S后退出（车端）/请前往处理（手机）" 12 "中断时间超时，功能终止，3S后退出（车端）/请前往处理（手机）" 11 "中断次数超限，功能终止，3S后退出（车端）/请前往处理（手机）" 10 "轨迹内有障碍物，请处理后重试" 9 "系统检测到刹车，功能中断，松开刹车后，泊车继续" 8 "安全带未系，请系上安全带后重试" 7 "机舱盖开启，请关闭后重试" 6 "行李箱门开启，请关闭后重试" 5 "车门被打开，请关闭后重试" 4 "请系好安全带" 3 "请关闭机舱盖开启" 2 "请关闭行李箱门" 1 "请关闭车门" 0 "Normal";
VAL_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_FLM 4 "Zone4" 3 "Zone3" 2 "Zone2" 1 "Zone1" 0 "No Object";
VAL_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_FLC 4 "Zone4" 3 "Zone3" 2 "Zone2" 1 "Zone1" 0 "No Object";
VAL_ 404 ADCS8_RPA_CheckListDispReq8 1 "Not Satisfied" 0 "System is normal";
VAL_ 404 ADCS8_RPA_CheckListDispReq7 1 "Not Satisfied" 0 "System is normal";
VAL_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_FRC 4 "Zone4" 3 "Zone3" 2 "Zone2" 1 "Zone1" 0 "No Object";
VAL_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_FRM 4 "Zone4" 3 "Zone3" 2 "Zone2" 1 "Zone1" 0 "No Object";
VAL_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_RLM 4 "Zone4" 3 "Zone3" 2 "Zone2" 1 "Zone1" 0 "No Object";
VAL_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_RLC 4 "Zone4" 3 "Zone3" 2 "Zone2" 1 "Zone1" 0 "No Object";
VAL_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_RRC 4 "Zone4" 3 "Zone3" 2 "Zone2" 1 "Zone1" 0 "No Object";
VAL_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_RRM 4 "Zone4" 3 "Zone3" 2 "Zone2" 1 "Zone1" 0 "No Object";
VAL_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_SFR 4 "Zone4" 3 "Zone3" 2 "Zone2" 1 "Zone1" 0 "No Object";
VAL_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_SFL 4 "Zone4" 3 "Zone3" 2 "Zone2" 1 "Zone1" 0 "No Object";
VAL_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_SRR 4 "Zone4" 3 "Zone3" 2 "Zone2" 1 "Zone1" 0 "No Object";
VAL_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_SRL 4 "Zone4" 3 "Zone3" 2 "Zone2" 1 "Zone1" 0 "No Object";
VAL_ 404 ADCS8_PA_FPAS_SnsrDist_FLC 255 "Invalid";
VAL_ 404 ADCS8_PA_FPAS_SnsrDist_FLM 255 "Invalid";
VAL_ 404 ADCS8_PA_FPAS_SnsrDist_FRM 255 "Invalid";
VAL_ 404 ADCS8_PA_FPAS_SnsrDist_FRC 255 "Invalid";
VAL_ 404 ADCS8_PA_FPAS_SnsrDist_RLC 255 "Invalid";
VAL_ 404 ADCS8_PA_FPAS_SnsrDist_RLM 255 "Invalid";
VAL_ 404 ADCS8_PA_FPAS_SnsrDist_RRM 255 "Invalid";
VAL_ 404 ADCS8_PA_FPAS_SnsrDist_RRC 255 "Invalid";
VAL_ 404 ADCS8_PA_FPAS_SnsrDist_SFL 511 "Invalid";
VAL_ 404 ADCS8_PA_FPAS_SnsrDist_SFR 511 "Invalid";
VAL_ 404 ADCS8_PA_FPAS_SnsrDist_SRL 511 "Invalid";
VAL_ 404 ADCS8_PA_FPAS_SnsrDist_SRR 511 "Invalid";
VAL_ 404 ADCS8_PA_FPAS_SensorFaultStsFRC 1 "Sensor fault" 0 "Sensor normal";
VAL_ 404 ADCS8_PA_FPAS_SensorFaultStsFRM 1 "Sensor fault" 0 "Sensor normal";
VAL_ 404 ADCS8_PA_FPAS_SensorFaultStsFLM 1 "Sensor fault" 0 "Sensor normal";
VAL_ 404 ADCS8_PA_FPAS_SensorFaultStsFLC 1 "Sensor fault" 0 "Sensor normal";
VAL_ 404 ADCS8_PA_RPAS_WorkSts 3 "Failed" 2 "Active" 1 "Standby" 0 "Disabled";
VAL_ 404 ADCS8_PA_FPAS_WorkSts 3 "Failed" 2 "Active" 1 "Standby" 0 "Disabled";
VAL_ 404 ADCS8_PA_RPAS_SensorFaultStsSRR 1 "Sensor fault" 0 "Sensor normal";
VAL_ 404 ADCS8_PA_RPAS_SensorFaultStsSRL 1 "Sensor fault" 0 "Sensor normal";
VAL_ 404 ADCS8_PA_FPAS_SensorFaultStsSFR 1 "Sensor fault" 0 "Sensor normal";
VAL_ 404 ADCS8_PA_FPAS_SensorFaultStsSFL 1 "Sensor fault" 0 "Sensor normal";
VAL_ 404 ADCS8_PA_RPAS_SensorFaultStsRRC 1 "Sensor fault" 0 "Sensor normal";
VAL_ 404 ADCS8_PA_RPAS_SensorFaultStsRRM 1 "Sensor fault" 0 "Sensor normal";
VAL_ 404 ADCS8_PA_RPAS_SensorFaultStsRLM 1 "Sensor fault" 0 "Sensor normal";
VAL_ 404 ADCS8_PA_RPAS_SensorFaultStsRLC 1 "Sensor fault" 0 "Sensor normal";
VAL_ 404 ADCS8_AudBpRate_R 6 "Warning Level 4_R" 5 "Warning Level 3_R" 4 "Warning Level 2_R" 3 "Warning Level 1_R" 2 "SyStem fault" 1 "System normal" 0 "No Request";
VAL_ 404 ADCS8_AudBpRate_F 6 "Warning Level 4_F" 5 "Warning Level 3_F" 4 "Warning Level 2_F" 3 "Warning Level 1_F" 2 "SyStem fault" 1 "System normal" 0 "No Request";
VAL_ 404 ADCS8_AVM_MODWarning 1 "Warning" 0 "No warning";
VAL_ 404 ADCS8_AVM_RomoteAVMFeedBack 1 "On" 0 "Off";
VAL_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_RSDW 4 "Zone4" 3 "Zone3" 2 "Zone2" 1 "Zone1" 0 "No Object";
VAL_ 404 ADCS8_PA_FPAS_SnsrObjWrnngZn_LSDW 4 "Zone4" 3 "Zone3" 2 "Zone2" 1 "Zone1" 0 "No Object";
VAL_ 404 ADCS8_PA_WarningType 3 "Reserved" 2 "TTS" 1 "Beep" 0 "No Action";
VAL_ 404 ADCS8_PA_FPAS_SnsrObjWrnnglc_RSDW 3 "Air3" 2 "Air2" 1 "Air1" 0 "Norequst";
VAL_ 404 ADCS8_PA_FPAS_SnsrObjWrnnglc_LSDW 3 "Air3" 2 "Air2" 1 "Air1" 0 "Norequst";
VAL_ 404 ADCS8_Beepreq 7 "type7" 6 "type6" 5 "type 5" 4 "type 4" 3 "type 3" 2 "type 2" 1 "type 1" 0 "No req";
VAL_ 404 ADCS8_Mod_Object_MovingDirection 15 "Reserve" 9 "Reserve" 8 "Right Rear Side" 7 "Right Side" 6 "Right Front Side" 5 "Front Side" 4 "Left Front Side" 3 "Left Side" 2 "Left Rear Side" 1 "Rear Side" 0 "No Object";
VAL_ 404 ADCS8_TBA_text 24 "摄像头故障，请及时前往售后检查" 23 "当前无视频流输入，请及时前往售后检查" 22 "无法预期完成循迹倒车，功能即将退出" 21 "功能中止，循迹倒车即将退出" 20 "车辆无记忆路径，循迹倒车不可用" 19 "松开刹车及方向盘，循迹倒车开始" 18 "循迹倒车已完成" 17 "检测到刹车，松开刹车后可自动恢复循迹倒车" 16 "检测到障碍物，移除障碍物后，点击继续恢复循迹倒车" 15 "关闭前舱盖后，点击继续恢复循迹倒车" 14 "关闭后备箱后，点击继续恢复循迹倒车" 13 "关闭车门后，点击继续恢复循迹倒车" 12 "系好安全带后，点击继续恢复循迹倒车" 11 "循迹倒车中，请注意周边环境" 10 "中断超时，循迹倒车即将退出" 9 "驾驶员干预，循迹倒车即将退出" 8 "泊车系统故障，循迹倒车即将退出" 7 "坡度过大，循迹倒车即将退出" 6 "中断次数超限，循迹倒车即将退出" 5 "车辆发生溜坡，循迹倒车即将退出" 4 "行车辅助功能激活，循迹倒车即将退出" 3 "关联系统故障，循迹倒车即将退出" 2 "泊车超速，循迹倒车即将退出" 1 "车辆受阻，循迹倒车即将退出" 0 "Normal";
VAL_ 404 ADCS5_RPA_slot_ID_9_Status 7 "Reserved" 6 "Reserved" 5 "Reserved" 4 "unknown" 3 "Selected" 2 "Unavailable" 1 "Available" 0 "default";
VAL_ 404 ADCS5_RPA_ParkingSlotType9 3 "Oblique" 2 "Parallel" 1 "Vertical" 0 "Undecided";
VAL_ 404 ADCS5_RPA_ParkingSlotDirection9 2 "Right" 1 "Left" 0 "No";
VAL_ 406 ADCS5_RPA_slot_ID_10_Status 7 "Reserved" 6 "Reserved" 5 "Reserved" 4 "unknown" 3 "Selected" 2 "Unavailable" 1 "Available" 0 "default";
VAL_ 406 ADCS5_RPA_ParkingSlotType10 3 "Oblique" 2 "Parallel" 1 "Vertical" 0 "Undecided";
VAL_ 406 ADCS5_RPA_ParkingSlotDirection10 2 "Right" 1 "Left" 0 "No";
VAL_ 406 ADCS5_RPA_slot_ID_11_Status 7 "Reserved" 6 "Reserved" 5 "Reserved" 4 "unknown" 3 "Selected" 2 "Unavailable" 1 "Available" 0 "default";
VAL_ 406 ADCS5_RPA_ParkingSlotType11 3 "Oblique" 2 "Parallel" 1 "Vertical" 0 "Undecided";
VAL_ 406 ADCS5_RPA_ParkingSlotDirection11 2 "Right" 1 "Left" 0 "No";
VAL_ 406 ADCS5_RPA_slot_ID_12_Status 7 "Reserved" 6 "Reserved" 5 "Reserved" 4 "unknown" 3 "Selected" 2 "Unavailable" 1 "Available" 0 "default";
VAL_ 406 ADCS5_RPA_ParkingSlotType12 3 "Oblique" 2 "Parallel" 1 "Vertical" 0 "Undecided";
VAL_ 406 ADCS5_RPA_ParkingSlotDirection12 2 "Right" 1 "Left" 0 "No";
VAL_ 460 ID1_PA_object_Type 255 "Reserved" 254 "Reserved" 253 "Reserved" 252 "Reserved" 251 "Reserved" 250 "Reserved" 249 "Reserved" 248 "Reserved" 247 "Reserved" 246 "Reserved" 245 "Reserved" 244 "Reserved" 243 "Reserved" 242 "Reserved" 241 "Reserved" 240 "Reserved" 239 "Reserved" 238 "Reserved" 237 "Reserved" 236 "Reserved" 235 "Reserved" 234 "Reserved" 233 "Reserved" 232 "Reserved" 231 "Reserved" 230 "Reserved" 229 "Reserved" 228 "Reserved" 227 "Reserved" 226 "Reserved" 225 "Reserved" 224 "Reserved" 223 "Reserved" 222 "Reserved" 221 "Reserved" 220 "Reserved" 219 "Reserved" 218 "Reserved" 217 "Reserved" 216 "Reserved" 215 "Reserved" 214 "Reserved" 213 "Reserved" 212 "Reserved" 211 "Reserved" 210 "Reserved" 209 "Reserved" 208 "Reserved" 207 "Reserved" 206 "Reserved" 205 "Reserved" 204 "Reserved" 203 "Reserved" 202 "Reserved" 201 "Reserved" 200 "Reserved" 199 "Reserved" 198 "Reserved" 197 "Reserved" 196 "Reserved" 195 "Reserved" 194 "Reserved" 193 "Reserved" 192 "Reserved" 191 "Reserved" 190 "Reserved" 189 "Reserved" 188 "Reserved" 187 "Reserved" 186 "Reserved" 185 "Reserved" 184 "Reserved" 183 "Reserved" 182 "Reserved" 181 "Reserved" 180 "Reserved" 179 "Reserved" 178 "Reserved" 177 "Reserved" 176 "Reserved" 175 "Reserved" 174 "Reserved" 173 "Reserved" 172 "Reserved" 171 "Reserved" 170 "Reserved" 169 "Reserved" 168 "Reserved" 167 "Reserved" 166 "Reserved" 165 "Reserved" 164 "Reserved" 163 "Reserved" 162 "Reserved" 161 "Reserved" 160 "Reserved" 159 "Reserved" 158 "Reserved" 157 "Reserved" 156 "Reserved" 155 "Reserved" 154 "Reserved" 153 "Reserved" 152 "Reserved" 151 "Reserved" 150 "Reserved" 149 "Reserved" 148 "Reserved" 147 "Reserved" 146 "Reserved" 145 "Reserved" 144 "Reserved" 143 "Reserved" 142 "Reserved" 141 "Reserved" 140 "Reserved" 139 "Reserved" 138 "Reserved" 137 "Reserved" 136 "Reserved" 135 "Reserved" 134 "Reserved" 133 "Reserved" 132 "Reserved" 131 "Reserved" 130 "Reserved" 129 "Reserved" 128 "Reserved" 127 "Reserved" 126 "Reserved" 125 "Reserved" 124 "Reserved" 123 "Reserved" 122 "Reserved" 121 "Reserved" 120 "Reserved" 119 "Reserved" 118 "Reserved" 117 "Reserved" 116 "Reserved" 115 "Reserved" 114 "Reserved" 113 "Reserved" 112 "Reserved" 111 "Reserved" 110 "Reserved" 109 "Reserved" 108 "Reserved" 107 "Reserved" 106 "Reserved" 105 "Reserved" 104 "Reserved" 103 "Reserved" 102 "Reserved" 101 "Reserved" 100 "Reserved" 99 "Reserved" 98 "Reserved" 97 "Reserved" 96 "Reserved" 95 "Reserved" 94 "Reserved" 93 "Reserved" 92 "Reserved" 91 "Reserved" 90 "Reserved" 89 "Reserved" 88 "Reserved" 87 "Reserved" 86 "Reserved" 85 "Reserved" 84 "Reserved" 83 "Reserved" 82 "Reserved" 81 "Reserved" 80 "Reserved" 79 "Reserved" 78 "Reserved" 77 "Reserved" 76 "Reserved" 75 "Reserved" 74 "Reserved" 73 "Reserved" 72 "Reserved" 71 "Reserved" 70 "Reserved" 69 "Reserved" 68 "Reserved" 67 "Reserved" 66 "Reserved" 65 "Reserved" 64 "Reserved" 63 "Reserved" 62 "Reserved" 61 "Reserved" 60 "Reserved" 59 "Reserved" 58 "Reserved" 57 "Reserved" 56 "Reserved" 55 "Reserved" 54 "Reserved" 53 "Reserved" 52 "Reserved" 51 "Reserved" 50 "Reserved" 49 "Reserved" 48 "Reserved" 47 "Reserved" 46 "Reserved" 45 "Reserved" 44 "Reserved" 43 "Reserved" 42 "Reserved" 41 "Reserved" 40 "Reserved" 39 "Reserved" 38 "Reserved" 37 "Reserved" 36 "Reserved" 35 "Reserved" 34 "Reserved" 33 "Reserved" 32 "Reserved" 31 "Reserved" 30 "Reserved" 29 "Reserved" 28 "Reserved" 27 "Reserved" 26 "Reserved" 25 "轮档" 24 "地锁关" 23 "地锁开" 22 "反光立柱" 21 "柱子" 20 "减速带" 19 "停车杆（预留）" 18 "禁停牌（预留）" 17 "三角牌" 16 "水马" 15 "锥桶" 14 "Animal（预留）" 13 "工程车（预留）" 12 "Firetruck（预留）" 11 "Ambulance（预留）" 10 "Minibus（预留）" 9 "SUV（预留）" 8 "Special" 7 "Bus客车、公交" 6 "Truck卡车" 5 "Car轿车" 4 "Tricycle三轮车（预留）" 3 "Motobike摩托车" 2 "自行车" 1 "行人" 0 "无";
VAL_ 460 ID2_PA_object_Type 255 "Reserved" 254 "Reserved" 253 "Reserved" 252 "Reserved" 251 "Reserved" 250 "Reserved" 249 "Reserved" 248 "Reserved" 247 "Reserved" 246 "Reserved" 245 "Reserved" 244 "Reserved" 243 "Reserved" 242 "Reserved" 241 "Reserved" 240 "Reserved" 239 "Reserved" 238 "Reserved" 237 "Reserved" 236 "Reserved" 235 "Reserved" 234 "Reserved" 233 "Reserved" 232 "Reserved" 231 "Reserved" 230 "Reserved" 229 "Reserved" 228 "Reserved" 227 "Reserved" 226 "Reserved" 225 "Reserved" 224 "Reserved" 223 "Reserved" 222 "Reserved" 221 "Reserved" 220 "Reserved" 219 "Reserved" 218 "Reserved" 217 "Reserved" 216 "Reserved" 215 "Reserved" 214 "Reserved" 213 "Reserved" 212 "Reserved" 211 "Reserved" 210 "Reserved" 209 "Reserved" 208 "Reserved" 207 "Reserved" 206 "Reserved" 205 "Reserved" 204 "Reserved" 203 "Reserved" 202 "Reserved" 201 "Reserved" 200 "Reserved" 199 "Reserved" 198 "Reserved" 197 "Reserved" 196 "Reserved" 195 "Reserved" 194 "Reserved" 193 "Reserved" 192 "Reserved" 191 "Reserved" 190 "Reserved" 189 "Reserved" 188 "Reserved" 187 "Reserved" 186 "Reserved" 185 "Reserved" 184 "Reserved" 183 "Reserved" 182 "Reserved" 181 "Reserved" 180 "Reserved" 179 "Reserved" 178 "Reserved" 177 "Reserved" 176 "Reserved" 175 "Reserved" 174 "Reserved" 173 "Reserved" 172 "Reserved" 171 "Reserved" 170 "Reserved" 169 "Reserved" 168 "Reserved" 167 "Reserved" 166 "Reserved" 165 "Reserved" 164 "Reserved" 163 "Reserved" 162 "Reserved" 161 "Reserved" 160 "Reserved" 159 "Reserved" 158 "Reserved" 157 "Reserved" 156 "Reserved" 155 "Reserved" 154 "Reserved" 153 "Reserved" 152 "Reserved" 151 "Reserved" 150 "Reserved" 149 "Reserved" 148 "Reserved" 147 "Reserved" 146 "Reserved" 145 "Reserved" 144 "Reserved" 143 "Reserved" 142 "Reserved" 141 "Reserved" 140 "Reserved" 139 "Reserved" 138 "Reserved" 137 "Reserved" 136 "Reserved" 135 "Reserved" 134 "Reserved" 133 "Reserved" 132 "Reserved" 131 "Reserved" 130 "Reserved" 129 "Reserved" 128 "Reserved" 127 "Reserved" 126 "Reserved" 125 "Reserved" 124 "Reserved" 123 "Reserved" 122 "Reserved" 121 "Reserved" 120 "Reserved" 119 "Reserved" 118 "Reserved" 117 "Reserved" 116 "Reserved" 115 "Reserved" 114 "Reserved" 113 "Reserved" 112 "Reserved" 111 "Reserved" 110 "Reserved" 109 "Reserved" 108 "Reserved" 107 "Reserved" 106 "Reserved" 105 "Reserved" 104 "Reserved" 103 "Reserved" 102 "Reserved" 101 "Reserved" 100 "Reserved" 99 "Reserved" 98 "Reserved" 97 "Reserved" 96 "Reserved" 95 "Reserved" 94 "Reserved" 93 "Reserved" 92 "Reserved" 91 "Reserved" 90 "Reserved" 89 "Reserved" 88 "Reserved" 87 "Reserved" 86 "Reserved" 85 "Reserved" 84 "Reserved" 83 "Reserved" 82 "Reserved" 81 "Reserved" 80 "Reserved" 79 "Reserved" 78 "Reserved" 77 "Reserved" 76 "Reserved" 75 "Reserved" 74 "Reserved" 73 "Reserved" 72 "Reserved" 71 "Reserved" 70 "Reserved" 69 "Reserved" 68 "Reserved" 67 "Reserved" 66 "Reserved" 65 "Reserved" 64 "Reserved" 63 "Reserved" 62 "Reserved" 61 "Reserved" 60 "Reserved" 59 "Reserved" 58 "Reserved" 57 "Reserved" 56 "Reserved" 55 "Reserved" 54 "Reserved" 53 "Reserved" 52 "Reserved" 51 "Reserved" 50 "Reserved" 49 "Reserved" 48 "Reserved" 47 "Reserved" 46 "Reserved" 45 "Reserved" 44 "Reserved" 43 "Reserved" 42 "Reserved" 41 "Reserved" 40 "Reserved" 39 "Reserved" 38 "Reserved" 37 "Reserved" 36 "Reserved" 35 "Reserved" 34 "Reserved" 33 "Reserved" 32 "Reserved" 31 "Reserved" 30 "Reserved" 29 "Reserved" 28 "Reserved" 27 "Reserved" 26 "Reserved" 25 "轮档" 24 "地锁关" 23 "地锁开" 22 "反光立柱" 21 "柱子" 20 "减速带" 19 "停车杆（预留）" 18 "禁停牌（预留）" 17 "三角牌" 16 "水马" 15 "锥桶" 14 "Animal（预留）" 13 "工程车（预留）" 12 "Firetruck（预留）" 11 "Ambulance（预留）" 10 "Minibus（预留）" 9 "SUV（预留）" 8 "Special" 7 "Bus客车、公交" 6 "Truck卡车" 5 "Car轿车" 4 "Tricycle三轮车（预留）" 3 "Motobike摩托车" 2 "自行车" 1 "行人" 0 "无";
VAL_ 460 ID3_PA_object_Type 255 "Reserved" 254 "Reserved" 253 "Reserved" 252 "Reserved" 251 "Reserved" 250 "Reserved" 249 "Reserved" 248 "Reserved" 247 "Reserved" 246 "Reserved" 245 "Reserved" 244 "Reserved" 243 "Reserved" 242 "Reserved" 241 "Reserved" 240 "Reserved" 239 "Reserved" 238 "Reserved" 237 "Reserved" 236 "Reserved" 235 "Reserved" 234 "Reserved" 233 "Reserved" 232 "Reserved" 231 "Reserved" 230 "Reserved" 229 "Reserved" 228 "Reserved" 227 "Reserved" 226 "Reserved" 225 "Reserved" 224 "Reserved" 223 "Reserved" 222 "Reserved" 221 "Reserved" 220 "Reserved" 219 "Reserved" 218 "Reserved" 217 "Reserved" 216 "Reserved" 215 "Reserved" 214 "Reserved" 213 "Reserved" 212 "Reserved" 211 "Reserved" 210 "Reserved" 209 "Reserved" 208 "Reserved" 207 "Reserved" 206 "Reserved" 205 "Reserved" 204 "Reserved" 203 "Reserved" 202 "Reserved" 201 "Reserved" 200 "Reserved" 199 "Reserved" 198 "Reserved" 197 "Reserved" 196 "Reserved" 195 "Reserved" 194 "Reserved" 193 "Reserved" 192 "Reserved" 191 "Reserved" 190 "Reserved" 189 "Reserved" 188 "Reserved" 187 "Reserved" 186 "Reserved" 185 "Reserved" 184 "Reserved" 183 "Reserved" 182 "Reserved" 181 "Reserved" 180 "Reserved" 179 "Reserved" 178 "Reserved" 177 "Reserved" 176 "Reserved" 175 "Reserved" 174 "Reserved" 173 "Reserved" 172 "Reserved" 171 "Reserved" 170 "Reserved" 169 "Reserved" 168 "Reserved" 167 "Reserved" 166 "Reserved" 165 "Reserved" 164 "Reserved" 163 "Reserved" 162 "Reserved" 161 "Reserved" 160 "Reserved" 159 "Reserved" 158 "Reserved" 157 "Reserved" 156 "Reserved" 155 "Reserved" 154 "Reserved" 153 "Reserved" 152 "Reserved" 151 "Reserved" 150 "Reserved" 149 "Reserved" 148 "Reserved" 147 "Reserved" 146 "Reserved" 145 "Reserved" 144 "Reserved" 143 "Reserved" 142 "Reserved" 141 "Reserved" 140 "Reserved" 139 "Reserved" 138 "Reserved" 137 "Reserved" 136 "Reserved" 135 "Reserved" 134 "Reserved" 133 "Reserved" 132 "Reserved" 131 "Reserved" 130 "Reserved" 129 "Reserved" 128 "Reserved" 127 "Reserved" 126 "Reserved" 125 "Reserved" 124 "Reserved" 123 "Reserved" 122 "Reserved" 121 "Reserved" 120 "Reserved" 119 "Reserved" 118 "Reserved" 117 "Reserved" 116 "Reserved" 115 "Reserved" 114 "Reserved" 113 "Reserved" 112 "Reserved" 111 "Reserved" 110 "Reserved" 109 "Reserved" 108 "Reserved" 107 "Reserved" 106 "Reserved" 105 "Reserved" 104 "Reserved" 103 "Reserved" 102 "Reserved" 101 "Reserved" 100 "Reserved" 99 "Reserved" 98 "Reserved" 97 "Reserved" 96 "Reserved" 95 "Reserved" 94 "Reserved" 93 "Reserved" 92 "Reserved" 91 "Reserved" 90 "Reserved" 89 "Reserved" 88 "Reserved" 87 "Reserved" 86 "Reserved" 85 "Reserved" 84 "Reserved" 83 "Reserved" 82 "Reserved" 81 "Reserved" 80 "Reserved" 79 "Reserved" 78 "Reserved" 77 "Reserved" 76 "Reserved" 75 "Reserved" 74 "Reserved" 73 "Reserved" 72 "Reserved" 71 "Reserved" 70 "Reserved" 69 "Reserved" 68 "Reserved" 67 "Reserved" 66 "Reserved" 65 "Reserved" 64 "Reserved" 63 "Reserved" 62 "Reserved" 61 "Reserved" 60 "Reserved" 59 "Reserved" 58 "Reserved" 57 "Reserved" 56 "Reserved" 55 "Reserved" 54 "Reserved" 53 "Reserved" 52 "Reserved" 51 "Reserved" 50 "Reserved" 49 "Reserved" 48 "Reserved" 47 "Reserved" 46 "Reserved" 45 "Reserved" 44 "Reserved" 43 "Reserved" 42 "Reserved" 41 "Reserved" 40 "Reserved" 39 "Reserved" 38 "Reserved" 37 "Reserved" 36 "Reserved" 35 "Reserved" 34 "Reserved" 33 "Reserved" 32 "Reserved" 31 "Reserved" 30 "Reserved" 29 "Reserved" 28 "Reserved" 27 "Reserved" 26 "Reserved" 25 "轮档" 24 "地锁关" 23 "地锁开" 22 "反光立柱" 21 "柱子" 20 "减速带" 19 "停车杆（预留）" 18 "禁停牌（预留）" 17 "三角牌" 16 "水马" 15 "锥桶" 14 "Animal（预留）" 13 "工程车（预留）" 12 "Firetruck（预留）" 11 "Ambulance（预留）" 10 "Minibus（预留）" 9 "SUV（预留）" 8 "Special" 7 "Bus客车、公交" 6 "Truck卡车" 5 "Car轿车" 4 "Tricycle三轮车（预留）" 3 "Motobike摩托车" 2 "自行车" 1 "行人" 0 "无";
VAL_ 460 ID4_PA_object_Type 255 "Reserved" 254 "Reserved" 253 "Reserved" 252 "Reserved" 251 "Reserved" 250 "Reserved" 249 "Reserved" 248 "Reserved" 247 "Reserved" 246 "Reserved" 245 "Reserved" 244 "Reserved" 243 "Reserved" 242 "Reserved" 241 "Reserved" 240 "Reserved" 239 "Reserved" 238 "Reserved" 237 "Reserved" 236 "Reserved" 235 "Reserved" 234 "Reserved" 233 "Reserved" 232 "Reserved" 231 "Reserved" 230 "Reserved" 229 "Reserved" 228 "Reserved" 227 "Reserved" 226 "Reserved" 225 "Reserved" 224 "Reserved" 223 "Reserved" 222 "Reserved" 221 "Reserved" 220 "Reserved" 219 "Reserved" 218 "Reserved" 217 "Reserved" 216 "Reserved" 215 "Reserved" 214 "Reserved" 213 "Reserved" 212 "Reserved" 211 "Reserved" 210 "Reserved" 209 "Reserved" 208 "Reserved" 207 "Reserved" 206 "Reserved" 205 "Reserved" 204 "Reserved" 203 "Reserved" 202 "Reserved" 201 "Reserved" 200 "Reserved" 199 "Reserved" 198 "Reserved" 197 "Reserved" 196 "Reserved" 195 "Reserved" 194 "Reserved" 193 "Reserved" 192 "Reserved" 191 "Reserved" 190 "Reserved" 189 "Reserved" 188 "Reserved" 187 "Reserved" 186 "Reserved" 185 "Reserved" 184 "Reserved" 183 "Reserved" 182 "Reserved" 181 "Reserved" 180 "Reserved" 179 "Reserved" 178 "Reserved" 177 "Reserved" 176 "Reserved" 175 "Reserved" 174 "Reserved" 173 "Reserved" 172 "Reserved" 171 "Reserved" 170 "Reserved" 169 "Reserved" 168 "Reserved" 167 "Reserved" 166 "Reserved" 165 "Reserved" 164 "Reserved" 163 "Reserved" 162 "Reserved" 161 "Reserved" 160 "Reserved" 159 "Reserved" 158 "Reserved" 157 "Reserved" 156 "Reserved" 155 "Reserved" 154 "Reserved" 153 "Reserved" 152 "Reserved" 151 "Reserved" 150 "Reserved" 149 "Reserved" 148 "Reserved" 147 "Reserved" 146 "Reserved" 145 "Reserved" 144 "Reserved" 143 "Reserved" 142 "Reserved" 141 "Reserved" 140 "Reserved" 139 "Reserved" 138 "Reserved" 137 "Reserved" 136 "Reserved" 135 "Reserved" 134 "Reserved" 133 "Reserved" 132 "Reserved" 131 "Reserved" 130 "Reserved" 129 "Reserved" 128 "Reserved" 127 "Reserved" 126 "Reserved" 125 "Reserved" 124 "Reserved" 123 "Reserved" 122 "Reserved" 121 "Reserved" 120 "Reserved" 119 "Reserved" 118 "Reserved" 117 "Reserved" 116 "Reserved" 115 "Reserved" 114 "Reserved" 113 "Reserved" 112 "Reserved" 111 "Reserved" 110 "Reserved" 109 "Reserved" 108 "Reserved" 107 "Reserved" 106 "Reserved" 105 "Reserved" 104 "Reserved" 103 "Reserved" 102 "Reserved" 101 "Reserved" 100 "Reserved" 99 "Reserved" 98 "Reserved" 97 "Reserved" 96 "Reserved" 95 "Reserved" 94 "Reserved" 93 "Reserved" 92 "Reserved" 91 "Reserved" 90 "Reserved" 89 "Reserved" 88 "Reserved" 87 "Reserved" 86 "Reserved" 85 "Reserved" 84 "Reserved" 83 "Reserved" 82 "Reserved" 81 "Reserved" 80 "Reserved" 79 "Reserved" 78 "Reserved" 77 "Reserved" 76 "Reserved" 75 "Reserved" 74 "Reserved" 73 "Reserved" 72 "Reserved" 71 "Reserved" 70 "Reserved" 69 "Reserved" 68 "Reserved" 67 "Reserved" 66 "Reserved" 65 "Reserved" 64 "Reserved" 63 "Reserved" 62 "Reserved" 61 "Reserved" 60 "Reserved" 59 "Reserved" 58 "Reserved" 57 "Reserved" 56 "Reserved" 55 "Reserved" 54 "Reserved" 53 "Reserved" 52 "Reserved" 51 "Reserved" 50 "Reserved" 49 "Reserved" 48 "Reserved" 47 "Reserved" 46 "Reserved" 45 "Reserved" 44 "Reserved" 43 "Reserved" 42 "Reserved" 41 "Reserved" 40 "Reserved" 39 "Reserved" 38 "Reserved" 37 "Reserved" 36 "Reserved" 35 "Reserved" 34 "Reserved" 33 "Reserved" 32 "Reserved" 31 "Reserved" 30 "Reserved" 29 "Reserved" 28 "Reserved" 27 "Reserved" 26 "Reserved" 25 "轮档" 24 "地锁关" 23 "地锁开" 22 "反光立柱" 21 "柱子" 20 "减速带" 19 "停车杆（预留）" 18 "禁停牌（预留）" 17 "三角牌" 16 "水马" 15 "锥桶" 14 "Animal（预留）" 13 "工程车（预留）" 12 "Firetruck（预留）" 11 "Ambulance（预留）" 10 "Minibus（预留）" 9 "SUV（预留）" 8 "Special" 7 "Bus客车、公交" 6 "Truck卡车" 5 "Car轿车" 4 "Tricycle三轮车（预留）" 3 "Motobike摩托车" 2 "自行车" 1 "行人" 0 "无";
VAL_ 460 ID5_PA_object_Type 255 "Reserved" 254 "Reserved" 253 "Reserved" 252 "Reserved" 251 "Reserved" 250 "Reserved" 249 "Reserved" 248 "Reserved" 247 "Reserved" 246 "Reserved" 245 "Reserved" 244 "Reserved" 243 "Reserved" 242 "Reserved" 241 "Reserved" 240 "Reserved" 239 "Reserved" 238 "Reserved" 237 "Reserved" 236 "Reserved" 235 "Reserved" 234 "Reserved" 233 "Reserved" 232 "Reserved" 231 "Reserved" 230 "Reserved" 229 "Reserved" 228 "Reserved" 227 "Reserved" 226 "Reserved" 225 "Reserved" 224 "Reserved" 223 "Reserved" 222 "Reserved" 221 "Reserved" 220 "Reserved" 219 "Reserved" 218 "Reserved" 217 "Reserved" 216 "Reserved" 215 "Reserved" 214 "Reserved" 213 "Reserved" 212 "Reserved" 211 "Reserved" 210 "Reserved" 209 "Reserved" 208 "Reserved" 207 "Reserved" 206 "Reserved" 205 "Reserved" 204 "Reserved" 203 "Reserved" 202 "Reserved" 201 "Reserved" 200 "Reserved" 199 "Reserved" 198 "Reserved" 197 "Reserved" 196 "Reserved" 195 "Reserved" 194 "Reserved" 193 "Reserved" 192 "Reserved" 191 "Reserved" 190 "Reserved" 189 "Reserved" 188 "Reserved" 187 "Reserved" 186 "Reserved" 185 "Reserved" 184 "Reserved" 183 "Reserved" 182 "Reserved" 181 "Reserved" 180 "Reserved" 179 "Reserved" 178 "Reserved" 177 "Reserved" 176 "Reserved" 175 "Reserved" 174 "Reserved" 173 "Reserved" 172 "Reserved" 171 "Reserved" 170 "Reserved" 169 "Reserved" 168 "Reserved" 167 "Reserved" 166 "Reserved" 165 "Reserved" 164 "Reserved" 163 "Reserved" 162 "Reserved" 161 "Reserved" 160 "Reserved" 159 "Reserved" 158 "Reserved" 157 "Reserved" 156 "Reserved" 155 "Reserved" 154 "Reserved" 153 "Reserved" 152 "Reserved" 151 "Reserved" 150 "Reserved" 149 "Reserved" 148 "Reserved" 147 "Reserved" 146 "Reserved" 145 "Reserved" 144 "Reserved" 143 "Reserved" 142 "Reserved" 141 "Reserved" 140 "Reserved" 139 "Reserved" 138 "Reserved" 137 "Reserved" 136 "Reserved" 135 "Reserved" 134 "Reserved" 133 "Reserved" 132 "Reserved" 131 "Reserved" 130 "Reserved" 129 "Reserved" 128 "Reserved" 127 "Reserved" 126 "Reserved" 125 "Reserved" 124 "Reserved" 123 "Reserved" 122 "Reserved" 121 "Reserved" 120 "Reserved" 119 "Reserved" 118 "Reserved" 117 "Reserved" 116 "Reserved" 115 "Reserved" 114 "Reserved" 113 "Reserved" 112 "Reserved" 111 "Reserved" 110 "Reserved" 109 "Reserved" 108 "Reserved" 107 "Reserved" 106 "Reserved" 105 "Reserved" 104 "Reserved" 103 "Reserved" 102 "Reserved" 101 "Reserved" 100 "Reserved" 99 "Reserved" 98 "Reserved" 97 "Reserved" 96 "Reserved" 95 "Reserved" 94 "Reserved" 93 "Reserved" 92 "Reserved" 91 "Reserved" 90 "Reserved" 89 "Reserved" 88 "Reserved" 87 "Reserved" 86 "Reserved" 85 "Reserved" 84 "Reserved" 83 "Reserved" 82 "Reserved" 81 "Reserved" 80 "Reserved" 79 "Reserved" 78 "Reserved" 77 "Reserved" 76 "Reserved" 75 "Reserved" 74 "Reserved" 73 "Reserved" 72 "Reserved" 71 "Reserved" 70 "Reserved" 69 "Reserved" 68 "Reserved" 67 "Reserved" 66 "Reserved" 65 "Reserved" 64 "Reserved" 63 "Reserved" 62 "Reserved" 61 "Reserved" 60 "Reserved" 59 "Reserved" 58 "Reserved" 57 "Reserved" 56 "Reserved" 55 "Reserved" 54 "Reserved" 53 "Reserved" 52 "Reserved" 51 "Reserved" 50 "Reserved" 49 "Reserved" 48 "Reserved" 47 "Reserved" 46 "Reserved" 45 "Reserved" 44 "Reserved" 43 "Reserved" 42 "Reserved" 41 "Reserved" 40 "Reserved" 39 "Reserved" 38 "Reserved" 37 "Reserved" 36 "Reserved" 35 "Reserved" 34 "Reserved" 33 "Reserved" 32 "Reserved" 31 "Reserved" 30 "Reserved" 29 "Reserved" 28 "Reserved" 27 "Reserved" 26 "Reserved" 25 "轮档" 24 "地锁关" 23 "地锁开" 22 "反光立柱" 21 "柱子" 20 "减速带" 19 "停车杆（预留）" 18 "禁停牌（预留）" 17 "三角牌" 16 "水马" 15 "锥桶" 14 "Animal（预留）" 13 "工程车（预留）" 12 "Firetruck（预留）" 11 "Ambulance（预留）" 10 "Minibus（预留）" 9 "SUV（预留）" 8 "Special" 7 "Bus客车、公交" 6 "Truck卡车" 5 "Car轿车" 4 "Tricycle三轮车（预留）" 3 "Motobike摩托车" 2 "自行车" 1 "行人" 0 "无";
VAL_ 460 ID6_PA_object_Type 255 "Reserved" 254 "Reserved" 253 "Reserved" 252 "Reserved" 251 "Reserved" 250 "Reserved" 249 "Reserved" 248 "Reserved" 247 "Reserved" 246 "Reserved" 245 "Reserved" 244 "Reserved" 243 "Reserved" 242 "Reserved" 241 "Reserved" 240 "Reserved" 239 "Reserved" 238 "Reserved" 237 "Reserved" 236 "Reserved" 235 "Reserved" 234 "Reserved" 233 "Reserved" 232 "Reserved" 231 "Reserved" 230 "Reserved" 229 "Reserved" 228 "Reserved" 227 "Reserved" 226 "Reserved" 225 "Reserved" 224 "Reserved" 223 "Reserved" 222 "Reserved" 221 "Reserved" 220 "Reserved" 219 "Reserved" 218 "Reserved" 217 "Reserved" 216 "Reserved" 215 "Reserved" 214 "Reserved" 213 "Reserved" 212 "Reserved" 211 "Reserved" 210 "Reserved" 209 "Reserved" 208 "Reserved" 207 "Reserved" 206 "Reserved" 205 "Reserved" 204 "Reserved" 203 "Reserved" 202 "Reserved" 201 "Reserved" 200 "Reserved" 199 "Reserved" 198 "Reserved" 197 "Reserved" 196 "Reserved" 195 "Reserved" 194 "Reserved" 193 "Reserved" 192 "Reserved" 191 "Reserved" 190 "Reserved" 189 "Reserved" 188 "Reserved" 187 "Reserved" 186 "Reserved" 185 "Reserved" 184 "Reserved" 183 "Reserved" 182 "Reserved" 181 "Reserved" 180 "Reserved" 179 "Reserved" 178 "Reserved" 177 "Reserved" 176 "Reserved" 175 "Reserved" 174 "Reserved" 173 "Reserved" 172 "Reserved" 171 "Reserved" 170 "Reserved" 169 "Reserved" 168 "Reserved" 167 "Reserved" 166 "Reserved" 165 "Reserved" 164 "Reserved" 163 "Reserved" 162 "Reserved" 161 "Reserved" 160 "Reserved" 159 "Reserved" 158 "Reserved" 157 "Reserved" 156 "Reserved" 155 "Reserved" 154 "Reserved" 153 "Reserved" 152 "Reserved" 151 "Reserved" 150 "Reserved" 149 "Reserved" 148 "Reserved" 147 "Reserved" 146 "Reserved" 145 "Reserved" 144 "Reserved" 143 "Reserved" 142 "Reserved" 141 "Reserved" 140 "Reserved" 139 "Reserved" 138 "Reserved" 137 "Reserved" 136 "Reserved" 135 "Reserved" 134 "Reserved" 133 "Reserved" 132 "Reserved" 131 "Reserved" 130 "Reserved" 129 "Reserved" 128 "Reserved" 127 "Reserved" 126 "Reserved" 125 "Reserved" 124 "Reserved" 123 "Reserved" 122 "Reserved" 121 "Reserved" 120 "Reserved" 119 "Reserved" 118 "Reserved" 117 "Reserved" 116 "Reserved" 115 "Reserved" 114 "Reserved" 113 "Reserved" 112 "Reserved" 111 "Reserved" 110 "Reserved" 109 "Reserved" 108 "Reserved" 107 "Reserved" 106 "Reserved" 105 "Reserved" 104 "Reserved" 103 "Reserved" 102 "Reserved" 101 "Reserved" 100 "Reserved" 99 "Reserved" 98 "Reserved" 97 "Reserved" 96 "Reserved" 95 "Reserved" 94 "Reserved" 93 "Reserved" 92 "Reserved" 91 "Reserved" 90 "Reserved" 89 "Reserved" 88 "Reserved" 87 "Reserved" 86 "Reserved" 85 "Reserved" 84 "Reserved" 83 "Reserved" 82 "Reserved" 81 "Reserved" 80 "Reserved" 79 "Reserved" 78 "Reserved" 77 "Reserved" 76 "Reserved" 75 "Reserved" 74 "Reserved" 73 "Reserved" 72 "Reserved" 71 "Reserved" 70 "Reserved" 69 "Reserved" 68 "Reserved" 67 "Reserved" 66 "Reserved" 65 "Reserved" 64 "Reserved" 63 "Reserved" 62 "Reserved" 61 "Reserved" 60 "Reserved" 59 "Reserved" 58 "Reserved" 57 "Reserved" 56 "Reserved" 55 "Reserved" 54 "Reserved" 53 "Reserved" 52 "Reserved" 51 "Reserved" 50 "Reserved" 49 "Reserved" 48 "Reserved" 47 "Reserved" 46 "Reserved" 45 "Reserved" 44 "Reserved" 43 "Reserved" 42 "Reserved" 41 "Reserved" 40 "Reserved" 39 "Reserved" 38 "Reserved" 37 "Reserved" 36 "Reserved" 35 "Reserved" 34 "Reserved" 33 "Reserved" 32 "Reserved" 31 "Reserved" 30 "Reserved" 29 "Reserved" 28 "Reserved" 27 "Reserved" 26 "Reserved" 25 "轮档" 24 "地锁关" 23 "地锁开" 22 "反光立柱" 21 "柱子" 20 "减速带" 19 "停车杆（预留）" 18 "禁停牌（预留）" 17 "三角牌" 16 "水马" 15 "锥桶" 14 "Animal（预留）" 13 "工程车（预留）" 12 "Firetruck（预留）" 11 "Ambulance（预留）" 10 "Minibus（预留）" 9 "SUV（预留）" 8 "Special" 7 "Bus客车、公交" 6 "Truck卡车" 5 "Car轿车" 4 "Tricycle三轮车（预留）" 3 "Motobike摩托车" 2 "自行车" 1 "行人" 0 "无";
VAL_ 460 ID7_PA_object_Type 255 "Reserved" 254 "Reserved" 253 "Reserved" 252 "Reserved" 251 "Reserved" 250 "Reserved" 249 "Reserved" 248 "Reserved" 247 "Reserved" 246 "Reserved" 245 "Reserved" 244 "Reserved" 243 "Reserved" 242 "Reserved" 241 "Reserved" 240 "Reserved" 239 "Reserved" 238 "Reserved" 237 "Reserved" 236 "Reserved" 235 "Reserved" 234 "Reserved" 233 "Reserved" 232 "Reserved" 231 "Reserved" 230 "Reserved" 229 "Reserved" 228 "Reserved" 227 "Reserved" 226 "Reserved" 225 "Reserved" 224 "Reserved" 223 "Reserved" 222 "Reserved" 221 "Reserved" 220 "Reserved" 219 "Reserved" 218 "Reserved" 217 "Reserved" 216 "Reserved" 215 "Reserved" 214 "Reserved" 213 "Reserved" 212 "Reserved" 211 "Reserved" 210 "Reserved" 209 "Reserved" 208 "Reserved" 207 "Reserved" 206 "Reserved" 205 "Reserved" 204 "Reserved" 203 "Reserved" 202 "Reserved" 201 "Reserved" 200 "Reserved" 199 "Reserved" 198 "Reserved" 197 "Reserved" 196 "Reserved" 195 "Reserved" 194 "Reserved" 193 "Reserved" 192 "Reserved" 191 "Reserved" 190 "Reserved" 189 "Reserved" 188 "Reserved" 187 "Reserved" 186 "Reserved" 185 "Reserved" 184 "Reserved" 183 "Reserved" 182 "Reserved" 181 "Reserved" 180 "Reserved" 179 "Reserved" 178 "Reserved" 177 "Reserved" 176 "Reserved" 175 "Reserved" 174 "Reserved" 173 "Reserved" 172 "Reserved" 171 "Reserved" 170 "Reserved" 169 "Reserved" 168 "Reserved" 167 "Reserved" 166 "Reserved" 165 "Reserved" 164 "Reserved" 163 "Reserved" 162 "Reserved" 161 "Reserved" 160 "Reserved" 159 "Reserved" 158 "Reserved" 157 "Reserved" 156 "Reserved" 155 "Reserved" 154 "Reserved" 153 "Reserved" 152 "Reserved" 151 "Reserved" 150 "Reserved" 149 "Reserved" 148 "Reserved" 147 "Reserved" 146 "Reserved" 145 "Reserved" 144 "Reserved" 143 "Reserved" 142 "Reserved" 141 "Reserved" 140 "Reserved" 139 "Reserved" 138 "Reserved" 137 "Reserved" 136 "Reserved" 135 "Reserved" 134 "Reserved" 133 "Reserved" 132 "Reserved" 131 "Reserved" 130 "Reserved" 129 "Reserved" 128 "Reserved" 127 "Reserved" 126 "Reserved" 125 "Reserved" 124 "Reserved" 123 "Reserved" 122 "Reserved" 121 "Reserved" 120 "Reserved" 119 "Reserved" 118 "Reserved" 117 "Reserved" 116 "Reserved" 115 "Reserved" 114 "Reserved" 113 "Reserved" 112 "Reserved" 111 "Reserved" 110 "Reserved" 109 "Reserved" 108 "Reserved" 107 "Reserved" 106 "Reserved" 105 "Reserved" 104 "Reserved" 103 "Reserved" 102 "Reserved" 101 "Reserved" 100 "Reserved" 99 "Reserved" 98 "Reserved" 97 "Reserved" 96 "Reserved" 95 "Reserved" 94 "Reserved" 93 "Reserved" 92 "Reserved" 91 "Reserved" 90 "Reserved" 89 "Reserved" 88 "Reserved" 87 "Reserved" 86 "Reserved" 85 "Reserved" 84 "Reserved" 83 "Reserved" 82 "Reserved" 81 "Reserved" 80 "Reserved" 79 "Reserved" 78 "Reserved" 77 "Reserved" 76 "Reserved" 75 "Reserved" 74 "Reserved" 73 "Reserved" 72 "Reserved" 71 "Reserved" 70 "Reserved" 69 "Reserved" 68 "Reserved" 67 "Reserved" 66 "Reserved" 65 "Reserved" 64 "Reserved" 63 "Reserved" 62 "Reserved" 61 "Reserved" 60 "Reserved" 59 "Reserved" 58 "Reserved" 57 "Reserved" 56 "Reserved" 55 "Reserved" 54 "Reserved" 53 "Reserved" 52 "Reserved" 51 "Reserved" 50 "Reserved" 49 "Reserved" 48 "Reserved" 47 "Reserved" 46 "Reserved" 45 "Reserved" 44 "Reserved" 43 "Reserved" 42 "Reserved" 41 "Reserved" 40 "Reserved" 39 "Reserved" 38 "Reserved" 37 "Reserved" 36 "Reserved" 35 "Reserved" 34 "Reserved" 33 "Reserved" 32 "Reserved" 31 "Reserved" 30 "Reserved" 29 "Reserved" 28 "Reserved" 27 "Reserved" 26 "Reserved" 25 "轮档" 24 "地锁关" 23 "地锁开" 22 "反光立柱" 21 "柱子" 20 "减速带" 19 "停车杆（预留）" 18 "禁停牌（预留）" 17 "三角牌" 16 "水马" 15 "锥桶" 14 "Animal（预留）" 13 "工程车（预留）" 12 "Firetruck（预留）" 11 "Ambulance（预留）" 10 "Minibus（预留）" 9 "SUV（预留）" 8 "Special" 7 "Bus客车、公交" 6 "Truck卡车" 5 "Car轿车" 4 "Tricycle三轮车（预留）" 3 "Motobike摩托车" 2 "自行车" 1 "行人" 0 "无";
VAL_ 460 ID8_PA_object_Type 255 "Reserved" 254 "Reserved" 253 "Reserved" 252 "Reserved" 251 "Reserved" 250 "Reserved" 249 "Reserved" 248 "Reserved" 247 "Reserved" 246 "Reserved" 245 "Reserved" 244 "Reserved" 243 "Reserved" 242 "Reserved" 241 "Reserved" 240 "Reserved" 239 "Reserved" 238 "Reserved" 237 "Reserved" 236 "Reserved" 235 "Reserved" 234 "Reserved" 233 "Reserved" 232 "Reserved" 231 "Reserved" 230 "Reserved" 229 "Reserved" 228 "Reserved" 227 "Reserved" 226 "Reserved" 225 "Reserved" 224 "Reserved" 223 "Reserved" 222 "Reserved" 221 "Reserved" 220 "Reserved" 219 "Reserved" 218 "Reserved" 217 "Reserved" 216 "Reserved" 215 "Reserved" 214 "Reserved" 213 "Reserved" 212 "Reserved" 211 "Reserved" 210 "Reserved" 209 "Reserved" 208 "Reserved" 207 "Reserved" 206 "Reserved" 205 "Reserved" 204 "Reserved" 203 "Reserved" 202 "Reserved" 201 "Reserved" 200 "Reserved" 199 "Reserved" 198 "Reserved" 197 "Reserved" 196 "Reserved" 195 "Reserved" 194 "Reserved" 193 "Reserved" 192 "Reserved" 191 "Reserved" 190 "Reserved" 189 "Reserved" 188 "Reserved" 187 "Reserved" 186 "Reserved" 185 "Reserved" 184 "Reserved" 183 "Reserved" 182 "Reserved" 181 "Reserved" 180 "Reserved" 179 "Reserved" 178 "Reserved" 177 "Reserved" 176 "Reserved" 175 "Reserved" 174 "Reserved" 173 "Reserved" 172 "Reserved" 171 "Reserved" 170 "Reserved" 169 "Reserved" 168 "Reserved" 167 "Reserved" 166 "Reserved" 165 "Reserved" 164 "Reserved" 163 "Reserved" 162 "Reserved" 161 "Reserved" 160 "Reserved" 159 "Reserved" 158 "Reserved" 157 "Reserved" 156 "Reserved" 155 "Reserved" 154 "Reserved" 153 "Reserved" 152 "Reserved" 151 "Reserved" 150 "Reserved" 149 "Reserved" 148 "Reserved" 147 "Reserved" 146 "Reserved" 145 "Reserved" 144 "Reserved" 143 "Reserved" 142 "Reserved" 141 "Reserved" 140 "Reserved" 139 "Reserved" 138 "Reserved" 137 "Reserved" 136 "Reserved" 135 "Reserved" 134 "Reserved" 133 "Reserved" 132 "Reserved" 131 "Reserved" 130 "Reserved" 129 "Reserved" 128 "Reserved" 127 "Reserved" 126 "Reserved" 125 "Reserved" 124 "Reserved" 123 "Reserved" 122 "Reserved" 121 "Reserved" 120 "Reserved" 119 "Reserved" 118 "Reserved" 117 "Reserved" 116 "Reserved" 115 "Reserved" 114 "Reserved" 113 "Reserved" 112 "Reserved" 111 "Reserved" 110 "Reserved" 109 "Reserved" 108 "Reserved" 107 "Reserved" 106 "Reserved" 105 "Reserved" 104 "Reserved" 103 "Reserved" 102 "Reserved" 101 "Reserved" 100 "Reserved" 99 "Reserved" 98 "Reserved" 97 "Reserved" 96 "Reserved" 95 "Reserved" 94 "Reserved" 93 "Reserved" 92 "Reserved" 91 "Reserved" 90 "Reserved" 89 "Reserved" 88 "Reserved" 87 "Reserved" 86 "Reserved" 85 "Reserved" 84 "Reserved" 83 "Reserved" 82 "Reserved" 81 "Reserved" 80 "Reserved" 79 "Reserved" 78 "Reserved" 77 "Reserved" 76 "Reserved" 75 "Reserved" 74 "Reserved" 73 "Reserved" 72 "Reserved" 71 "Reserved" 70 "Reserved" 69 "Reserved" 68 "Reserved" 67 "Reserved" 66 "Reserved" 65 "Reserved" 64 "Reserved" 63 "Reserved" 62 "Reserved" 61 "Reserved" 60 "Reserved" 59 "Reserved" 58 "Reserved" 57 "Reserved" 56 "Reserved" 55 "Reserved" 54 "Reserved" 53 "Reserved" 52 "Reserved" 51 "Reserved" 50 "Reserved" 49 "Reserved" 48 "Reserved" 47 "Reserved" 46 "Reserved" 45 "Reserved" 44 "Reserved" 43 "Reserved" 42 "Reserved" 41 "Reserved" 40 "Reserved" 39 "Reserved" 38 "Reserved" 37 "Reserved" 36 "Reserved" 35 "Reserved" 34 "Reserved" 33 "Reserved" 32 "Reserved" 31 "Reserved" 30 "Reserved" 29 "Reserved" 28 "Reserved" 27 "Reserved" 26 "Reserved" 25 "轮档" 24 "地锁关" 23 "地锁开" 22 "反光立柱" 21 "柱子" 20 "减速带" 19 "停车杆（预留）" 18 "禁停牌（预留）" 17 "三角牌" 16 "水马" 15 "锥桶" 14 "Animal（预留）" 13 "工程车（预留）" 12 "Firetruck（预留）" 11 "Ambulance（预留）" 10 "Minibus（预留）" 9 "SUV（预留）" 8 "Special" 7 "Bus客车、公交" 6 "Truck卡车" 5 "Car轿车" 4 "Tricycle三轮车（预留）" 3 "Motobike摩托车" 2 "自行车" 1 "行人" 0 "无";
VAL_ 461 ID9_PA_object_Type 255 "Reserved" 254 "Reserved" 253 "Reserved" 252 "Reserved" 251 "Reserved" 250 "Reserved" 249 "Reserved" 248 "Reserved" 247 "Reserved" 246 "Reserved" 245 "Reserved" 244 "Reserved" 243 "Reserved" 242 "Reserved" 241 "Reserved" 240 "Reserved" 239 "Reserved" 238 "Reserved" 237 "Reserved" 236 "Reserved" 235 "Reserved" 234 "Reserved" 233 "Reserved" 232 "Reserved" 231 "Reserved" 230 "Reserved" 229 "Reserved" 228 "Reserved" 227 "Reserved" 226 "Reserved" 225 "Reserved" 224 "Reserved" 223 "Reserved" 222 "Reserved" 221 "Reserved" 220 "Reserved" 219 "Reserved" 218 "Reserved" 217 "Reserved" 216 "Reserved" 215 "Reserved" 214 "Reserved" 213 "Reserved" 212 "Reserved" 211 "Reserved" 210 "Reserved" 209 "Reserved" 208 "Reserved" 207 "Reserved" 206 "Reserved" 205 "Reserved" 204 "Reserved" 203 "Reserved" 202 "Reserved" 201 "Reserved" 200 "Reserved" 199 "Reserved" 198 "Reserved" 197 "Reserved" 196 "Reserved" 195 "Reserved" 194 "Reserved" 193 "Reserved" 192 "Reserved" 191 "Reserved" 190 "Reserved" 189 "Reserved" 188 "Reserved" 187 "Reserved" 186 "Reserved" 185 "Reserved" 184 "Reserved" 183 "Reserved" 182 "Reserved" 181 "Reserved" 180 "Reserved" 179 "Reserved" 178 "Reserved" 177 "Reserved" 176 "Reserved" 175 "Reserved" 174 "Reserved" 173 "Reserved" 172 "Reserved" 171 "Reserved" 170 "Reserved" 169 "Reserved" 168 "Reserved" 167 "Reserved" 166 "Reserved" 165 "Reserved" 164 "Reserved" 163 "Reserved" 162 "Reserved" 161 "Reserved" 160 "Reserved" 159 "Reserved" 158 "Reserved" 157 "Reserved" 156 "Reserved" 155 "Reserved" 154 "Reserved" 153 "Reserved" 152 "Reserved" 151 "Reserved" 150 "Reserved" 149 "Reserved" 148 "Reserved" 147 "Reserved" 146 "Reserved" 145 "Reserved" 144 "Reserved" 143 "Reserved" 142 "Reserved" 141 "Reserved" 140 "Reserved" 139 "Reserved" 138 "Reserved" 137 "Reserved" 136 "Reserved" 135 "Reserved" 134 "Reserved" 133 "Reserved" 132 "Reserved" 131 "Reserved" 130 "Reserved" 129 "Reserved" 128 "Reserved" 127 "Reserved" 126 "Reserved" 125 "Reserved" 124 "Reserved" 123 "Reserved" 122 "Reserved" 121 "Reserved" 120 "Reserved" 119 "Reserved" 118 "Reserved" 117 "Reserved" 116 "Reserved" 115 "Reserved" 114 "Reserved" 113 "Reserved" 112 "Reserved" 111 "Reserved" 110 "Reserved" 109 "Reserved" 108 "Reserved" 107 "Reserved" 106 "Reserved" 105 "Reserved" 104 "Reserved" 103 "Reserved" 102 "Reserved" 101 "Reserved" 100 "Reserved" 99 "Reserved" 98 "Reserved" 97 "Reserved" 96 "Reserved" 95 "Reserved" 94 "Reserved" 93 "Reserved" 92 "Reserved" 91 "Reserved" 90 "Reserved" 89 "Reserved" 88 "Reserved" 87 "Reserved" 86 "Reserved" 85 "Reserved" 84 "Reserved" 83 "Reserved" 82 "Reserved" 81 "Reserved" 80 "Reserved" 79 "Reserved" 78 "Reserved" 77 "Reserved" 76 "Reserved" 75 "Reserved" 74 "Reserved" 73 "Reserved" 72 "Reserved" 71 "Reserved" 70 "Reserved" 69 "Reserved" 68 "Reserved" 67 "Reserved" 66 "Reserved" 65 "Reserved" 64 "Reserved" 63 "Reserved" 62 "Reserved" 61 "Reserved" 60 "Reserved" 59 "Reserved" 58 "Reserved" 57 "Reserved" 56 "Reserved" 55 "Reserved" 54 "Reserved" 53 "Reserved" 52 "Reserved" 51 "Reserved" 50 "Reserved" 49 "Reserved" 48 "Reserved" 47 "Reserved" 46 "Reserved" 45 "Reserved" 44 "Reserved" 43 "Reserved" 42 "Reserved" 41 "Reserved" 40 "Reserved" 39 "Reserved" 38 "Reserved" 37 "Reserved" 36 "Reserved" 35 "Reserved" 34 "Reserved" 33 "Reserved" 32 "Reserved" 31 "Reserved" 30 "Reserved" 29 "Reserved" 28 "Reserved" 27 "Reserved" 26 "Reserved" 25 "轮档" 24 "地锁关" 23 "地锁开" 22 "反光立柱" 21 "柱子" 20 "减速带" 19 "停车杆（预留）" 18 "禁停牌（预留）" 17 "三角牌" 16 "水马" 15 "锥桶" 14 "Animal（预留）" 13 "工程车（预留）" 12 "Firetruck（预留）" 11 "Ambulance（预留）" 10 "Minibus（预留）" 9 "SUV（预留）" 8 "Special" 7 "Bus客车、公交" 6 "Truck卡车" 5 "Car轿车" 4 "Tricycle三轮车（预留）" 3 "Motobike摩托车" 2 "自行车" 1 "行人" 0 "无";
VAL_ 461 ID10_PA_object_Type 255 "Reserved" 254 "Reserved" 253 "Reserved" 252 "Reserved" 251 "Reserved" 250 "Reserved" 249 "Reserved" 248 "Reserved" 247 "Reserved" 246 "Reserved" 245 "Reserved" 244 "Reserved" 243 "Reserved" 242 "Reserved" 241 "Reserved" 240 "Reserved" 239 "Reserved" 238 "Reserved" 237 "Reserved" 236 "Reserved" 235 "Reserved" 234 "Reserved" 233 "Reserved" 232 "Reserved" 231 "Reserved" 230 "Reserved" 229 "Reserved" 228 "Reserved" 227 "Reserved" 226 "Reserved" 225 "Reserved" 224 "Reserved" 223 "Reserved" 222 "Reserved" 221 "Reserved" 220 "Reserved" 219 "Reserved" 218 "Reserved" 217 "Reserved" 216 "Reserved" 215 "Reserved" 214 "Reserved" 213 "Reserved" 212 "Reserved" 211 "Reserved" 210 "Reserved" 209 "Reserved" 208 "Reserved" 207 "Reserved" 206 "Reserved" 205 "Reserved" 204 "Reserved" 203 "Reserved" 202 "Reserved" 201 "Reserved" 200 "Reserved" 199 "Reserved" 198 "Reserved" 197 "Reserved" 196 "Reserved" 195 "Reserved" 194 "Reserved" 193 "Reserved" 192 "Reserved" 191 "Reserved" 190 "Reserved" 189 "Reserved" 188 "Reserved" 187 "Reserved" 186 "Reserved" 185 "Reserved" 184 "Reserved" 183 "Reserved" 182 "Reserved" 181 "Reserved" 180 "Reserved" 179 "Reserved" 178 "Reserved" 177 "Reserved" 176 "Reserved" 175 "Reserved" 174 "Reserved" 173 "Reserved" 172 "Reserved" 171 "Reserved" 170 "Reserved" 169 "Reserved" 168 "Reserved" 167 "Reserved" 166 "Reserved" 165 "Reserved" 164 "Reserved" 163 "Reserved" 162 "Reserved" 161 "Reserved" 160 "Reserved" 159 "Reserved" 158 "Reserved" 157 "Reserved" 156 "Reserved" 155 "Reserved" 154 "Reserved" 153 "Reserved" 152 "Reserved" 151 "Reserved" 150 "Reserved" 149 "Reserved" 148 "Reserved" 147 "Reserved" 146 "Reserved" 145 "Reserved" 144 "Reserved" 143 "Reserved" 142 "Reserved" 141 "Reserved" 140 "Reserved" 139 "Reserved" 138 "Reserved" 137 "Reserved" 136 "Reserved" 135 "Reserved" 134 "Reserved" 133 "Reserved" 132 "Reserved" 131 "Reserved" 130 "Reserved" 129 "Reserved" 128 "Reserved" 127 "Reserved" 126 "Reserved" 125 "Reserved" 124 "Reserved" 123 "Reserved" 122 "Reserved" 121 "Reserved" 120 "Reserved" 119 "Reserved" 118 "Reserved" 117 "Reserved" 116 "Reserved" 115 "Reserved" 114 "Reserved" 113 "Reserved" 112 "Reserved" 111 "Reserved" 110 "Reserved" 109 "Reserved" 108 "Reserved" 107 "Reserved" 106 "Reserved" 105 "Reserved" 104 "Reserved" 103 "Reserved" 102 "Reserved" 101 "Reserved" 100 "Reserved" 99 "Reserved" 98 "Reserved" 97 "Reserved" 96 "Reserved" 95 "Reserved" 94 "Reserved" 93 "Reserved" 92 "Reserved" 91 "Reserved" 90 "Reserved" 89 "Reserved" 88 "Reserved" 87 "Reserved" 86 "Reserved" 85 "Reserved" 84 "Reserved" 83 "Reserved" 82 "Reserved" 81 "Reserved" 80 "Reserved" 79 "Reserved" 78 "Reserved" 77 "Reserved" 76 "Reserved" 75 "Reserved" 74 "Reserved" 73 "Reserved" 72 "Reserved" 71 "Reserved" 70 "Reserved" 69 "Reserved" 68 "Reserved" 67 "Reserved" 66 "Reserved" 65 "Reserved" 64 "Reserved" 63 "Reserved" 62 "Reserved" 61 "Reserved" 60 "Reserved" 59 "Reserved" 58 "Reserved" 57 "Reserved" 56 "Reserved" 55 "Reserved" 54 "Reserved" 53 "Reserved" 52 "Reserved" 51 "Reserved" 50 "Reserved" 49 "Reserved" 48 "Reserved" 47 "Reserved" 46 "Reserved" 45 "Reserved" 44 "Reserved" 43 "Reserved" 42 "Reserved" 41 "Reserved" 40 "Reserved" 39 "Reserved" 38 "Reserved" 37 "Reserved" 36 "Reserved" 35 "Reserved" 34 "Reserved" 33 "Reserved" 32 "Reserved" 31 "Reserved" 30 "Reserved" 29 "Reserved" 28 "Reserved" 27 "Reserved" 26 "Reserved" 25 "轮档" 24 "地锁关" 23 "地锁开" 22 "反光立柱" 21 "柱子" 20 "减速带" 19 "停车杆（预留）" 18 "禁停牌（预留）" 17 "三角牌" 16 "水马" 15 "锥桶" 14 "Animal（预留）" 13 "工程车（预留）" 12 "Firetruck（预留）" 11 "Ambulance（预留）" 10 "Minibus（预留）" 9 "SUV（预留）" 8 "Special" 7 "Bus客车、公交" 6 "Truck卡车" 5 "Car轿车" 4 "Tricycle三轮车（预留）" 3 "Motobike摩托车" 2 "自行车" 1 "行人" 0 "无";
VAL_ 461 ID11_PA_object_Type 255 "Reserved" 254 "Reserved" 253 "Reserved" 252 "Reserved" 251 "Reserved" 250 "Reserved" 249 "Reserved" 248 "Reserved" 247 "Reserved" 246 "Reserved" 245 "Reserved" 244 "Reserved" 243 "Reserved" 242 "Reserved" 241 "Reserved" 240 "Reserved" 239 "Reserved" 238 "Reserved" 237 "Reserved" 236 "Reserved" 235 "Reserved" 234 "Reserved" 233 "Reserved" 232 "Reserved" 231 "Reserved" 230 "Reserved" 229 "Reserved" 228 "Reserved" 227 "Reserved" 226 "Reserved" 225 "Reserved" 224 "Reserved" 223 "Reserved" 222 "Reserved" 221 "Reserved" 220 "Reserved" 219 "Reserved" 218 "Reserved" 217 "Reserved" 216 "Reserved" 215 "Reserved" 214 "Reserved" 213 "Reserved" 212 "Reserved" 211 "Reserved" 210 "Reserved" 209 "Reserved" 208 "Reserved" 207 "Reserved" 206 "Reserved" 205 "Reserved" 204 "Reserved" 203 "Reserved" 202 "Reserved" 201 "Reserved" 200 "Reserved" 199 "Reserved" 198 "Reserved" 197 "Reserved" 196 "Reserved" 195 "Reserved" 194 "Reserved" 193 "Reserved" 192 "Reserved" 191 "Reserved" 190 "Reserved" 189 "Reserved" 188 "Reserved" 187 "Reserved" 186 "Reserved" 185 "Reserved" 184 "Reserved" 183 "Reserved" 182 "Reserved" 181 "Reserved" 180 "Reserved" 179 "Reserved" 178 "Reserved" 177 "Reserved" 176 "Reserved" 175 "Reserved" 174 "Reserved" 173 "Reserved" 172 "Reserved" 171 "Reserved" 170 "Reserved" 169 "Reserved" 168 "Reserved" 167 "Reserved" 166 "Reserved" 165 "Reserved" 164 "Reserved" 163 "Reserved" 162 "Reserved" 161 "Reserved" 160 "Reserved" 159 "Reserved" 158 "Reserved" 157 "Reserved" 156 "Reserved" 155 "Reserved" 154 "Reserved" 153 "Reserved" 152 "Reserved" 151 "Reserved" 150 "Reserved" 149 "Reserved" 148 "Reserved" 147 "Reserved" 146 "Reserved" 145 "Reserved" 144 "Reserved" 143 "Reserved" 142 "Reserved" 141 "Reserved" 140 "Reserved" 139 "Reserved" 138 "Reserved" 137 "Reserved" 136 "Reserved" 135 "Reserved" 134 "Reserved" 133 "Reserved" 132 "Reserved" 131 "Reserved" 130 "Reserved" 129 "Reserved" 128 "Reserved" 127 "Reserved" 126 "Reserved" 125 "Reserved" 124 "Reserved" 123 "Reserved" 122 "Reserved" 121 "Reserved" 120 "Reserved" 119 "Reserved" 118 "Reserved" 117 "Reserved" 116 "Reserved" 115 "Reserved" 114 "Reserved" 113 "Reserved" 112 "Reserved" 111 "Reserved" 110 "Reserved" 109 "Reserved" 108 "Reserved" 107 "Reserved" 106 "Reserved" 105 "Reserved" 104 "Reserved" 103 "Reserved" 102 "Reserved" 101 "Reserved" 100 "Reserved" 99 "Reserved" 98 "Reserved" 97 "Reserved" 96 "Reserved" 95 "Reserved" 94 "Reserved" 93 "Reserved" 92 "Reserved" 91 "Reserved" 90 "Reserved" 89 "Reserved" 88 "Reserved" 87 "Reserved" 86 "Reserved" 85 "Reserved" 84 "Reserved" 83 "Reserved" 82 "Reserved" 81 "Reserved" 80 "Reserved" 79 "Reserved" 78 "Reserved" 77 "Reserved" 76 "Reserved" 75 "Reserved" 74 "Reserved" 73 "Reserved" 72 "Reserved" 71 "Reserved" 70 "Reserved" 69 "Reserved" 68 "Reserved" 67 "Reserved" 66 "Reserved" 65 "Reserved" 64 "Reserved" 63 "Reserved" 62 "Reserved" 61 "Reserved" 60 "Reserved" 59 "Reserved" 58 "Reserved" 57 "Reserved" 56 "Reserved" 55 "Reserved" 54 "Reserved" 53 "Reserved" 52 "Reserved" 51 "Reserved" 50 "Reserved" 49 "Reserved" 48 "Reserved" 47 "Reserved" 46 "Reserved" 45 "Reserved" 44 "Reserved" 43 "Reserved" 42 "Reserved" 41 "Reserved" 40 "Reserved" 39 "Reserved" 38 "Reserved" 37 "Reserved" 36 "Reserved" 35 "Reserved" 34 "Reserved" 33 "Reserved" 32 "Reserved" 31 "Reserved" 30 "Reserved" 29 "Reserved" 28 "Reserved" 27 "Reserved" 26 "Reserved" 25 "轮档" 24 "地锁关" 23 "地锁开" 22 "反光立柱" 21 "柱子" 20 "减速带" 19 "停车杆（预留）" 18 "禁停牌（预留）" 17 "三角牌" 16 "水马" 15 "锥桶" 14 "Animal（预留）" 13 "工程车（预留）" 12 "Firetruck（预留）" 11 "Ambulance（预留）" 10 "Minibus（预留）" 9 "SUV（预留）" 8 "Special" 7 "Bus客车、公交" 6 "Truck卡车" 5 "Car轿车" 4 "Tricycle三轮车（预留）" 3 "Motobike摩托车" 2 "自行车" 1 "行人" 0 "无";
VAL_ 461 ID12_PA_object_Type 255 "Reserved" 254 "Reserved" 253 "Reserved" 252 "Reserved" 251 "Reserved" 250 "Reserved" 249 "Reserved" 248 "Reserved" 247 "Reserved" 246 "Reserved" 245 "Reserved" 244 "Reserved" 243 "Reserved" 242 "Reserved" 241 "Reserved" 240 "Reserved" 239 "Reserved" 238 "Reserved" 237 "Reserved" 236 "Reserved" 235 "Reserved" 234 "Reserved" 233 "Reserved" 232 "Reserved" 231 "Reserved" 230 "Reserved" 229 "Reserved" 228 "Reserved" 227 "Reserved" 226 "Reserved" 225 "Reserved" 224 "Reserved" 223 "Reserved" 222 "Reserved" 221 "Reserved" 220 "Reserved" 219 "Reserved" 218 "Reserved" 217 "Reserved" 216 "Reserved" 215 "Reserved" 214 "Reserved" 213 "Reserved" 212 "Reserved" 211 "Reserved" 210 "Reserved" 209 "Reserved" 208 "Reserved" 207 "Reserved" 206 "Reserved" 205 "Reserved" 204 "Reserved" 203 "Reserved" 202 "Reserved" 201 "Reserved" 200 "Reserved" 199 "Reserved" 198 "Reserved" 197 "Reserved" 196 "Reserved" 195 "Reserved" 194 "Reserved" 193 "Reserved" 192 "Reserved" 191 "Reserved" 190 "Reserved" 189 "Reserved" 188 "Reserved" 187 "Reserved" 186 "Reserved" 185 "Reserved" 184 "Reserved" 183 "Reserved" 182 "Reserved" 181 "Reserved" 180 "Reserved" 179 "Reserved" 178 "Reserved" 177 "Reserved" 176 "Reserved" 175 "Reserved" 174 "Reserved" 173 "Reserved" 172 "Reserved" 171 "Reserved" 170 "Reserved" 169 "Reserved" 168 "Reserved" 167 "Reserved" 166 "Reserved" 165 "Reserved" 164 "Reserved" 163 "Reserved" 162 "Reserved" 161 "Reserved" 160 "Reserved" 159 "Reserved" 158 "Reserved" 157 "Reserved" 156 "Reserved" 155 "Reserved" 154 "Reserved" 153 "Reserved" 152 "Reserved" 151 "Reserved" 150 "Reserved" 149 "Reserved" 148 "Reserved" 147 "Reserved" 146 "Reserved" 145 "Reserved" 144 "Reserved" 143 "Reserved" 142 "Reserved" 141 "Reserved" 140 "Reserved" 139 "Reserved" 138 "Reserved" 137 "Reserved" 136 "Reserved" 135 "Reserved" 134 "Reserved" 133 "Reserved" 132 "Reserved" 131 "Reserved" 130 "Reserved" 129 "Reserved" 128 "Reserved" 127 "Reserved" 126 "Reserved" 125 "Reserved" 124 "Reserved" 123 "Reserved" 122 "Reserved" 121 "Reserved" 120 "Reserved" 119 "Reserved" 118 "Reserved" 117 "Reserved" 116 "Reserved" 115 "Reserved" 114 "Reserved" 113 "Reserved" 112 "Reserved" 111 "Reserved" 110 "Reserved" 109 "Reserved" 108 "Reserved" 107 "Reserved" 106 "Reserved" 105 "Reserved" 104 "Reserved" 103 "Reserved" 102 "Reserved" 101 "Reserved" 100 "Reserved" 99 "Reserved" 98 "Reserved" 97 "Reserved" 96 "Reserved" 95 "Reserved" 94 "Reserved" 93 "Reserved" 92 "Reserved" 91 "Reserved" 90 "Reserved" 89 "Reserved" 88 "Reserved" 87 "Reserved" 86 "Reserved" 85 "Reserved" 84 "Reserved" 83 "Reserved" 82 "Reserved" 81 "Reserved" 80 "Reserved" 79 "Reserved" 78 "Reserved" 77 "Reserved" 76 "Reserved" 75 "Reserved" 74 "Reserved" 73 "Reserved" 72 "Reserved" 71 "Reserved" 70 "Reserved" 69 "Reserved" 68 "Reserved" 67 "Reserved" 66 "Reserved" 65 "Reserved" 64 "Reserved" 63 "Reserved" 62 "Reserved" 61 "Reserved" 60 "Reserved" 59 "Reserved" 58 "Reserved" 57 "Reserved" 56 "Reserved" 55 "Reserved" 54 "Reserved" 53 "Reserved" 52 "Reserved" 51 "Reserved" 50 "Reserved" 49 "Reserved" 48 "Reserved" 47 "Reserved" 46 "Reserved" 45 "Reserved" 44 "Reserved" 43 "Reserved" 42 "Reserved" 41 "Reserved" 40 "Reserved" 39 "Reserved" 38 "Reserved" 37 "Reserved" 36 "Reserved" 35 "Reserved" 34 "Reserved" 33 "Reserved" 32 "Reserved" 31 "Reserved" 30 "Reserved" 29 "Reserved" 28 "Reserved" 27 "Reserved" 26 "Reserved" 25 "轮档" 24 "地锁关" 23 "地锁开" 22 "反光立柱" 21 "柱子" 20 "减速带" 19 "停车杆（预留）" 18 "禁停牌（预留）" 17 "三角牌" 16 "水马" 15 "锥桶" 14 "Animal（预留）" 13 "工程车（预留）" 12 "Firetruck（预留）" 11 "Ambulance（预留）" 10 "Minibus（预留）" 9 "SUV（预留）" 8 "Special" 7 "Bus客车、公交" 6 "Truck卡车" 5 "Car轿车" 4 "Tricycle三轮车（预留）" 3 "Motobike摩托车" 2 "自行车" 1 "行人" 0 "无";
VAL_ 461 ID13_PA_object_Type 255 "Reserved" 254 "Reserved" 253 "Reserved" 252 "Reserved" 251 "Reserved" 250 "Reserved" 249 "Reserved" 248 "Reserved" 247 "Reserved" 246 "Reserved" 245 "Reserved" 244 "Reserved" 243 "Reserved" 242 "Reserved" 241 "Reserved" 240 "Reserved" 239 "Reserved" 238 "Reserved" 237 "Reserved" 236 "Reserved" 235 "Reserved" 234 "Reserved" 233 "Reserved" 232 "Reserved" 231 "Reserved" 230 "Reserved" 229 "Reserved" 228 "Reserved" 227 "Reserved" 226 "Reserved" 225 "Reserved" 224 "Reserved" 223 "Reserved" 222 "Reserved" 221 "Reserved" 220 "Reserved" 219 "Reserved" 218 "Reserved" 217 "Reserved" 216 "Reserved" 215 "Reserved" 214 "Reserved" 213 "Reserved" 212 "Reserved" 211 "Reserved" 210 "Reserved" 209 "Reserved" 208 "Reserved" 207 "Reserved" 206 "Reserved" 205 "Reserved" 204 "Reserved" 203 "Reserved" 202 "Reserved" 201 "Reserved" 200 "Reserved" 199 "Reserved" 198 "Reserved" 197 "Reserved" 196 "Reserved" 195 "Reserved" 194 "Reserved" 193 "Reserved" 192 "Reserved" 191 "Reserved" 190 "Reserved" 189 "Reserved" 188 "Reserved" 187 "Reserved" 186 "Reserved" 185 "Reserved" 184 "Reserved" 183 "Reserved" 182 "Reserved" 181 "Reserved" 180 "Reserved" 179 "Reserved" 178 "Reserved" 177 "Reserved" 176 "Reserved" 175 "Reserved" 174 "Reserved" 173 "Reserved" 172 "Reserved" 171 "Reserved" 170 "Reserved" 169 "Reserved" 168 "Reserved" 167 "Reserved" 166 "Reserved" 165 "Reserved" 164 "Reserved" 163 "Reserved" 162 "Reserved" 161 "Reserved" 160 "Reserved" 159 "Reserved" 158 "Reserved" 157 "Reserved" 156 "Reserved" 155 "Reserved" 154 "Reserved" 153 "Reserved" 152 "Reserved" 151 "Reserved" 150 "Reserved" 149 "Reserved" 148 "Reserved" 147 "Reserved" 146 "Reserved" 145 "Reserved" 144 "Reserved" 143 "Reserved" 142 "Reserved" 141 "Reserved" 140 "Reserved" 139 "Reserved" 138 "Reserved" 137 "Reserved" 136 "Reserved" 135 "Reserved" 134 "Reserved" 133 "Reserved" 132 "Reserved" 131 "Reserved" 130 "Reserved" 129 "Reserved" 128 "Reserved" 127 "Reserved" 126 "Reserved" 125 "Reserved" 124 "Reserved" 123 "Reserved" 122 "Reserved" 121 "Reserved" 120 "Reserved" 119 "Reserved" 118 "Reserved" 117 "Reserved" 116 "Reserved" 115 "Reserved" 114 "Reserved" 113 "Reserved" 112 "Reserved" 111 "Reserved" 110 "Reserved" 109 "Reserved" 108 "Reserved" 107 "Reserved" 106 "Reserved" 105 "Reserved" 104 "Reserved" 103 "Reserved" 102 "Reserved" 101 "Reserved" 100 "Reserved" 99 "Reserved" 98 "Reserved" 97 "Reserved" 96 "Reserved" 95 "Reserved" 94 "Reserved" 93 "Reserved" 92 "Reserved" 91 "Reserved" 90 "Reserved" 89 "Reserved" 88 "Reserved" 87 "Reserved" 86 "Reserved" 85 "Reserved" 84 "Reserved" 83 "Reserved" 82 "Reserved" 81 "Reserved" 80 "Reserved" 79 "Reserved" 78 "Reserved" 77 "Reserved" 76 "Reserved" 75 "Reserved" 74 "Reserved" 73 "Reserved" 72 "Reserved" 71 "Reserved" 70 "Reserved" 69 "Reserved" 68 "Reserved" 67 "Reserved" 66 "Reserved" 65 "Reserved" 64 "Reserved" 63 "Reserved" 62 "Reserved" 61 "Reserved" 60 "Reserved" 59 "Reserved" 58 "Reserved" 57 "Reserved" 56 "Reserved" 55 "Reserved" 54 "Reserved" 53 "Reserved" 52 "Reserved" 51 "Reserved" 50 "Reserved" 49 "Reserved" 48 "Reserved" 47 "Reserved" 46 "Reserved" 45 "Reserved" 44 "Reserved" 43 "Reserved" 42 "Reserved" 41 "Reserved" 40 "Reserved" 39 "Reserved" 38 "Reserved" 37 "Reserved" 36 "Reserved" 35 "Reserved" 34 "Reserved" 33 "Reserved" 32 "Reserved" 31 "Reserved" 30 "Reserved" 29 "Reserved" 28 "Reserved" 27 "Reserved" 26 "Reserved" 25 "轮档" 24 "地锁关" 23 "地锁开" 22 "反光立柱" 21 "柱子" 20 "减速带" 19 "停车杆（预留）" 18 "禁停牌（预留）" 17 "三角牌" 16 "水马" 15 "锥桶" 14 "Animal（预留）" 13 "工程车（预留）" 12 "Firetruck（预留）" 11 "Ambulance（预留）" 10 "Minibus（预留）" 9 "SUV（预留）" 8 "Special" 7 "Bus客车、公交" 6 "Truck卡车" 5 "Car轿车" 4 "Tricycle三轮车（预留）" 3 "Motobike摩托车" 2 "自行车" 1 "行人" 0 "无";
VAL_ 461 ID14_PA_object_Type 255 "Reserved" 254 "Reserved" 253 "Reserved" 252 "Reserved" 251 "Reserved" 250 "Reserved" 249 "Reserved" 248 "Reserved" 247 "Reserved" 246 "Reserved" 245 "Reserved" 244 "Reserved" 243 "Reserved" 242 "Reserved" 241 "Reserved" 240 "Reserved" 239 "Reserved" 238 "Reserved" 237 "Reserved" 236 "Reserved" 235 "Reserved" 234 "Reserved" 233 "Reserved" 232 "Reserved" 231 "Reserved" 230 "Reserved" 229 "Reserved" 228 "Reserved" 227 "Reserved" 226 "Reserved" 225 "Reserved" 224 "Reserved" 223 "Reserved" 222 "Reserved" 221 "Reserved" 220 "Reserved" 219 "Reserved" 218 "Reserved" 217 "Reserved" 216 "Reserved" 215 "Reserved" 214 "Reserved" 213 "Reserved" 212 "Reserved" 211 "Reserved" 210 "Reserved" 209 "Reserved" 208 "Reserved" 207 "Reserved" 206 "Reserved" 205 "Reserved" 204 "Reserved" 203 "Reserved" 202 "Reserved" 201 "Reserved" 200 "Reserved" 199 "Reserved" 198 "Reserved" 197 "Reserved" 196 "Reserved" 195 "Reserved" 194 "Reserved" 193 "Reserved" 192 "Reserved" 191 "Reserved" 190 "Reserved" 189 "Reserved" 188 "Reserved" 187 "Reserved" 186 "Reserved" 185 "Reserved" 184 "Reserved" 183 "Reserved" 182 "Reserved" 181 "Reserved" 180 "Reserved" 179 "Reserved" 178 "Reserved" 177 "Reserved" 176 "Reserved" 175 "Reserved" 174 "Reserved" 173 "Reserved" 172 "Reserved" 171 "Reserved" 170 "Reserved" 169 "Reserved" 168 "Reserved" 167 "Reserved" 166 "Reserved" 165 "Reserved" 164 "Reserved" 163 "Reserved" 162 "Reserved" 161 "Reserved" 160 "Reserved" 159 "Reserved" 158 "Reserved" 157 "Reserved" 156 "Reserved" 155 "Reserved" 154 "Reserved" 153 "Reserved" 152 "Reserved" 151 "Reserved" 150 "Reserved" 149 "Reserved" 148 "Reserved" 147 "Reserved" 146 "Reserved" 145 "Reserved" 144 "Reserved" 143 "Reserved" 142 "Reserved" 141 "Reserved" 140 "Reserved" 139 "Reserved" 138 "Reserved" 137 "Reserved" 136 "Reserved" 135 "Reserved" 134 "Reserved" 133 "Reserved" 132 "Reserved" 131 "Reserved" 130 "Reserved" 129 "Reserved" 128 "Reserved" 127 "Reserved" 126 "Reserved" 125 "Reserved" 124 "Reserved" 123 "Reserved" 122 "Reserved" 121 "Reserved" 120 "Reserved" 119 "Reserved" 118 "Reserved" 117 "Reserved" 116 "Reserved" 115 "Reserved" 114 "Reserved" 113 "Reserved" 112 "Reserved" 111 "Reserved" 110 "Reserved" 109 "Reserved" 108 "Reserved" 107 "Reserved" 106 "Reserved" 105 "Reserved" 104 "Reserved" 103 "Reserved" 102 "Reserved" 101 "Reserved" 100 "Reserved" 99 "Reserved" 98 "Reserved" 97 "Reserved" 96 "Reserved" 95 "Reserved" 94 "Reserved" 93 "Reserved" 92 "Reserved" 91 "Reserved" 90 "Reserved" 89 "Reserved" 88 "Reserved" 87 "Reserved" 86 "Reserved" 85 "Reserved" 84 "Reserved" 83 "Reserved" 82 "Reserved" 81 "Reserved" 80 "Reserved" 79 "Reserved" 78 "Reserved" 77 "Reserved" 76 "Reserved" 75 "Reserved" 74 "Reserved" 73 "Reserved" 72 "Reserved" 71 "Reserved" 70 "Reserved" 69 "Reserved" 68 "Reserved" 67 "Reserved" 66 "Reserved" 65 "Reserved" 64 "Reserved" 63 "Reserved" 62 "Reserved" 61 "Reserved" 60 "Reserved" 59 "Reserved" 58 "Reserved" 57 "Reserved" 56 "Reserved" 55 "Reserved" 54 "Reserved" 53 "Reserved" 52 "Reserved" 51 "Reserved" 50 "Reserved" 49 "Reserved" 48 "Reserved" 47 "Reserved" 46 "Reserved" 45 "Reserved" 44 "Reserved" 43 "Reserved" 42 "Reserved" 41 "Reserved" 40 "Reserved" 39 "Reserved" 38 "Reserved" 37 "Reserved" 36 "Reserved" 35 "Reserved" 34 "Reserved" 33 "Reserved" 32 "Reserved" 31 "Reserved" 30 "Reserved" 29 "Reserved" 28 "Reserved" 27 "Reserved" 26 "Reserved" 25 "轮档" 24 "地锁关" 23 "地锁开" 22 "反光立柱" 21 "柱子" 20 "减速带" 19 "停车杆（预留）" 18 "禁停牌（预留）" 17 "三角牌" 16 "水马" 15 "锥桶" 14 "Animal（预留）" 13 "工程车（预留）" 12 "Firetruck（预留）" 11 "Ambulance（预留）" 10 "Minibus（预留）" 9 "SUV（预留）" 8 "Special" 7 "Bus客车、公交" 6 "Truck卡车" 5 "Car轿车" 4 "Tricycle三轮车（预留）" 3 "Motobike摩托车" 2 "自行车" 1 "行人" 0 "无";
VAL_ 461 ID15_PA_object_Type 255 "Reserved" 254 "Reserved" 253 "Reserved" 252 "Reserved" 251 "Reserved" 250 "Reserved" 249 "Reserved" 248 "Reserved" 247 "Reserved" 246 "Reserved" 245 "Reserved" 244 "Reserved" 243 "Reserved" 242 "Reserved" 241 "Reserved" 240 "Reserved" 239 "Reserved" 238 "Reserved" 237 "Reserved" 236 "Reserved" 235 "Reserved" 234 "Reserved" 233 "Reserved" 232 "Reserved" 231 "Reserved" 230 "Reserved" 229 "Reserved" 228 "Reserved" 227 "Reserved" 226 "Reserved" 225 "Reserved" 224 "Reserved" 223 "Reserved" 222 "Reserved" 221 "Reserved" 220 "Reserved" 219 "Reserved" 218 "Reserved" 217 "Reserved" 216 "Reserved" 215 "Reserved" 214 "Reserved" 213 "Reserved" 212 "Reserved" 211 "Reserved" 210 "Reserved" 209 "Reserved" 208 "Reserved" 207 "Reserved" 206 "Reserved" 205 "Reserved" 204 "Reserved" 203 "Reserved" 202 "Reserved" 201 "Reserved" 200 "Reserved" 199 "Reserved" 198 "Reserved" 197 "Reserved" 196 "Reserved" 195 "Reserved" 194 "Reserved" 193 "Reserved" 192 "Reserved" 191 "Reserved" 190 "Reserved" 189 "Reserved" 188 "Reserved" 187 "Reserved" 186 "Reserved" 185 "Reserved" 184 "Reserved" 183 "Reserved" 182 "Reserved" 181 "Reserved" 180 "Reserved" 179 "Reserved" 178 "Reserved" 177 "Reserved" 176 "Reserved" 175 "Reserved" 174 "Reserved" 173 "Reserved" 172 "Reserved" 171 "Reserved" 170 "Reserved" 169 "Reserved" 168 "Reserved" 167 "Reserved" 166 "Reserved" 165 "Reserved" 164 "Reserved" 163 "Reserved" 162 "Reserved" 161 "Reserved" 160 "Reserved" 159 "Reserved" 158 "Reserved" 157 "Reserved" 156 "Reserved" 155 "Reserved" 154 "Reserved" 153 "Reserved" 152 "Reserved" 151 "Reserved" 150 "Reserved" 149 "Reserved" 148 "Reserved" 147 "Reserved" 146 "Reserved" 145 "Reserved" 144 "Reserved" 143 "Reserved" 142 "Reserved" 141 "Reserved" 140 "Reserved" 139 "Reserved" 138 "Reserved" 137 "Reserved" 136 "Reserved" 135 "Reserved" 134 "Reserved" 133 "Reserved" 132 "Reserved" 131 "Reserved" 130 "Reserved" 129 "Reserved" 128 "Reserved" 127 "Reserved" 126 "Reserved" 125 "Reserved" 124 "Reserved" 123 "Reserved" 122 "Reserved" 121 "Reserved" 120 "Reserved" 119 "Reserved" 118 "Reserved" 117 "Reserved" 116 "Reserved" 115 "Reserved" 114 "Reserved" 113 "Reserved" 112 "Reserved" 111 "Reserved" 110 "Reserved" 109 "Reserved" 108 "Reserved" 107 "Reserved" 106 "Reserved" 105 "Reserved" 104 "Reserved" 103 "Reserved" 102 "Reserved" 101 "Reserved" 100 "Reserved" 99 "Reserved" 98 "Reserved" 97 "Reserved" 96 "Reserved" 95 "Reserved" 94 "Reserved" 93 "Reserved" 92 "Reserved" 91 "Reserved" 90 "Reserved" 89 "Reserved" 88 "Reserved" 87 "Reserved" 86 "Reserved" 85 "Reserved" 84 "Reserved" 83 "Reserved" 82 "Reserved" 81 "Reserved" 80 "Reserved" 79 "Reserved" 78 "Reserved" 77 "Reserved" 76 "Reserved" 75 "Reserved" 74 "Reserved" 73 "Reserved" 72 "Reserved" 71 "Reserved" 70 "Reserved" 69 "Reserved" 68 "Reserved" 67 "Reserved" 66 "Reserved" 65 "Reserved" 64 "Reserved" 63 "Reserved" 62 "Reserved" 61 "Reserved" 60 "Reserved" 59 "Reserved" 58 "Reserved" 57 "Reserved" 56 "Reserved" 55 "Reserved" 54 "Reserved" 53 "Reserved" 52 "Reserved" 51 "Reserved" 50 "Reserved" 49 "Reserved" 48 "Reserved" 47 "Reserved" 46 "Reserved" 45 "Reserved" 44 "Reserved" 43 "Reserved" 42 "Reserved" 41 "Reserved" 40 "Reserved" 39 "Reserved" 38 "Reserved" 37 "Reserved" 36 "Reserved" 35 "Reserved" 34 "Reserved" 33 "Reserved" 32 "Reserved" 31 "Reserved" 30 "Reserved" 29 "Reserved" 28 "Reserved" 27 "Reserved" 26 "Reserved" 25 "轮档" 24 "地锁关" 23 "地锁开" 22 "反光立柱" 21 "柱子" 20 "减速带" 19 "停车杆（预留）" 18 "禁停牌（预留）" 17 "三角牌" 16 "水马" 15 "锥桶" 14 "Animal（预留）" 13 "工程车（预留）" 12 "Firetruck（预留）" 11 "Ambulance（预留）" 10 "Minibus（预留）" 9 "SUV（预留）" 8 "Special" 7 "Bus客车、公交" 6 "Truck卡车" 5 "Car轿车" 4 "Tricycle三轮车（预留）" 3 "Motobike摩托车" 2 "自行车" 1 "行人" 0 "无";
VAL_ 461 ID16_PA_object_Type 255 "Reserved" 254 "Reserved" 253 "Reserved" 252 "Reserved" 251 "Reserved" 250 "Reserved" 249 "Reserved" 248 "Reserved" 247 "Reserved" 246 "Reserved" 245 "Reserved" 244 "Reserved" 243 "Reserved" 242 "Reserved" 241 "Reserved" 240 "Reserved" 239 "Reserved" 238 "Reserved" 237 "Reserved" 236 "Reserved" 235 "Reserved" 234 "Reserved" 233 "Reserved" 232 "Reserved" 231 "Reserved" 230 "Reserved" 229 "Reserved" 228 "Reserved" 227 "Reserved" 226 "Reserved" 225 "Reserved" 224 "Reserved" 223 "Reserved" 222 "Reserved" 221 "Reserved" 220 "Reserved" 219 "Reserved" 218 "Reserved" 217 "Reserved" 216 "Reserved" 215 "Reserved" 214 "Reserved" 213 "Reserved" 212 "Reserved" 211 "Reserved" 210 "Reserved" 209 "Reserved" 208 "Reserved" 207 "Reserved" 206 "Reserved" 205 "Reserved" 204 "Reserved" 203 "Reserved" 202 "Reserved" 201 "Reserved" 200 "Reserved" 199 "Reserved" 198 "Reserved" 197 "Reserved" 196 "Reserved" 195 "Reserved" 194 "Reserved" 193 "Reserved" 192 "Reserved" 191 "Reserved" 190 "Reserved" 189 "Reserved" 188 "Reserved" 187 "Reserved" 186 "Reserved" 185 "Reserved" 184 "Reserved" 183 "Reserved" 182 "Reserved" 181 "Reserved" 180 "Reserved" 179 "Reserved" 178 "Reserved" 177 "Reserved" 176 "Reserved" 175 "Reserved" 174 "Reserved" 173 "Reserved" 172 "Reserved" 171 "Reserved" 170 "Reserved" 169 "Reserved" 168 "Reserved" 167 "Reserved" 166 "Reserved" 165 "Reserved" 164 "Reserved" 163 "Reserved" 162 "Reserved" 161 "Reserved" 160 "Reserved" 159 "Reserved" 158 "Reserved" 157 "Reserved" 156 "Reserved" 155 "Reserved" 154 "Reserved" 153 "Reserved" 152 "Reserved" 151 "Reserved" 150 "Reserved" 149 "Reserved" 148 "Reserved" 147 "Reserved" 146 "Reserved" 145 "Reserved" 144 "Reserved" 143 "Reserved" 142 "Reserved" 141 "Reserved" 140 "Reserved" 139 "Reserved" 138 "Reserved" 137 "Reserved" 136 "Reserved" 135 "Reserved" 134 "Reserved" 133 "Reserved" 132 "Reserved" 131 "Reserved" 130 "Reserved" 129 "Reserved" 128 "Reserved" 127 "Reserved" 126 "Reserved" 125 "Reserved" 124 "Reserved" 123 "Reserved" 122 "Reserved" 121 "Reserved" 120 "Reserved" 119 "Reserved" 118 "Reserved" 117 "Reserved" 116 "Reserved" 115 "Reserved" 114 "Reserved" 113 "Reserved" 112 "Reserved" 111 "Reserved" 110 "Reserved" 109 "Reserved" 108 "Reserved" 107 "Reserved" 106 "Reserved" 105 "Reserved" 104 "Reserved" 103 "Reserved" 102 "Reserved" 101 "Reserved" 100 "Reserved" 99 "Reserved" 98 "Reserved" 97 "Reserved" 96 "Reserved" 95 "Reserved" 94 "Reserved" 93 "Reserved" 92 "Reserved" 91 "Reserved" 90 "Reserved" 89 "Reserved" 88 "Reserved" 87 "Reserved" 86 "Reserved" 85 "Reserved" 84 "Reserved" 83 "Reserved" 82 "Reserved" 81 "Reserved" 80 "Reserved" 79 "Reserved" 78 "Reserved" 77 "Reserved" 76 "Reserved" 75 "Reserved" 74 "Reserved" 73 "Reserved" 72 "Reserved" 71 "Reserved" 70 "Reserved" 69 "Reserved" 68 "Reserved" 67 "Reserved" 66 "Reserved" 65 "Reserved" 64 "Reserved" 63 "Reserved" 62 "Reserved" 61 "Reserved" 60 "Reserved" 59 "Reserved" 58 "Reserved" 57 "Reserved" 56 "Reserved" 55 "Reserved" 54 "Reserved" 53 "Reserved" 52 "Reserved" 51 "Reserved" 50 "Reserved" 49 "Reserved" 48 "Reserved" 47 "Reserved" 46 "Reserved" 45 "Reserved" 44 "Reserved" 43 "Reserved" 42 "Reserved" 41 "Reserved" 40 "Reserved" 39 "Reserved" 38 "Reserved" 37 "Reserved" 36 "Reserved" 35 "Reserved" 34 "Reserved" 33 "Reserved" 32 "Reserved" 31 "Reserved" 30 "Reserved" 29 "Reserved" 28 "Reserved" 27 "Reserved" 26 "Reserved" 25 "轮档" 24 "地锁关" 23 "地锁开" 22 "反光立柱" 21 "柱子" 20 "减速带" 19 "停车杆（预留）" 18 "禁停牌（预留）" 17 "三角牌" 16 "水马" 15 "锥桶" 14 "Animal（预留）" 13 "工程车（预留）" 12 "Firetruck（预留）" 11 "Ambulance（预留）" 10 "Minibus（预留）" 9 "SUV（预留）" 8 "Special" 7 "Bus客车、公交" 6 "Truck卡车" 5 "Car轿车" 4 "Tricycle三轮车（预留）" 3 "Motobike摩托车" 2 "自行车" 1 "行人" 0 "无";
